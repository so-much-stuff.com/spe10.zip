# EAGLE board spe10 (EAGLE 4.11), part 2 of 3
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
DATA05\  (via drill 0.61) (continued)
  Top 0.254: v13.97,62.23 13.97,37.47 12.7,36.2 C35L.12
  Bottom 0.254: v13.97,62.23 15.88,62.23 16.51,62.87 20.95,62.87 21.59,63.5 IC26.5
DATA06\  (via drill 0.61)
  Top 0.254: v11.43,57.15 11.43,40.01 12.7,38.73 C35L.14
  Bottom 0.254: v11.43,57.15 20.32,57.15 21.59,58.42 IC26.7
DATA07\  (via drill 0.61)
  Top 0.254: v19.05,52.07 18.41,51.44 v18.41,40.64
  Bottom 0.254: v19.05,52.07 20.32,52.07 21.59,53.34 IC26.9 | v18.41,40.64 17.14,39.37 14.61,39.37 13.34,40.64 C35L.16
DATA08\  (via drill 0.61)
  Top 0.254: v26.67,44.45 v26.67,50.8
  Bottom 0.254: v26.67,50.8 29.21,53.34 IC26.12 | v26.67,44.45 14.61,44.45 13.34,43.18 C35L.18
DATA09\  (via drill 0.61)
  Top 0.254: v28.57,49.53 28.57,56.52 29.84,57.78 IC26.14
  Bottom 0.254: v28.57,49.53 14.61,49.53 13.34,48.26 C35L.22
DATA10\
  Bottom 0.254: IC26.16 29.21,63.5 27.94,62.23 18.41,62.23 15.88,59.69 12.06,59.69 8.89,56.52 8.89,49.53 10.79,49.53 12.06,50.8 C35L.24
DATA11\  (via drill 0.61)
  Top 0.254: v26.67,54.61 26.67,64.77 29.84,67.94 IC26.18
  Bottom 0.254: v26.67,54.61 14.61,54.61 13.34,53.34 C35L.26
DATA_IN  (via drill 0.61)
  Top 0.254: v117.47,82.55 117.47,92.08 114.3,95.25 IC22.6 | v137.16,68.58 v137.16,80.01 | v186.69,67.31 187.96,66.04 v187.96,63.5
  Bottom 0.254: v117.47,82.55 118.75,81.28 130.18,81.28 130.81,81.92 131.44,81.92 133.35,80.01 v137.16,80.01 | v137.16,68.58 137.79,69.22 177.16,69.22 179.07,67.31 v186.69,67.31 | v187.96,63.5 193.04,58.42 200.03,58.42 C36L.30
DCXA\
  Top 0.254: IC18.9 169.54,118.75 168.28,118.75 IC18.10
  Bottom 0.254: IC16.12 109.86,120.02 111.12,121.28 153.03,121.28 153.67,121.92 165.1,121.92 167,120.02 IC18.10
DIMA\  (via drill 0.61)
  Top 0.254: IC37.1 210.82,31.11 210.82,35.56 212.72,37.47 212.72,59.05 211.46,60.33 IC30.1 | v215.9,112.39 215.9,60.96 217.81,59.05 IC30.19
  Bottom 0.254: v215.9,112.39 212.72,115.57 203.2,115.57 201.93,114.3 171.45,114.3 169.54,116.2 145.41,116.2 142.88,118.75 IC17.11 | IC30.1 212.09,60.96 214.63,58.42 217.17,58.42 IC30.19
DIML\  (via drill 0.61)
  Top 0.254: v140.97,102.87 140.97,116.84 139.7,118.11 IC17.12 | v201.93,59.69 201.93,20.32 200.66,19.05 INTENB.11
  Bottom 0.254: v140.97,102.87 141.6,103.5 145.41,103.5 146.05,104.14 163.83,104.14 165.1,102.87 177.16,102.87 179.71,100.33 212.09,100.33 221.62,90.81 221.62,76.2 220.34,76.2 | 220.34,76.2 219.71,76.2 FIELD.11 | v201.93,59.69 201.93,69.85 219.71,69.85 220.34,70.48 220.34,76.2
DIO00  (via drill 0.61)  (3 unrouted)
  Top 0.254: v52.07,121.92 50.8,120.65 IC14.12 | v68.58,27.94 68.58,25.4 73.03,20.95 IC35.12 | v15.88,20.32 15.88,13.97 12.7,10.79 SV1.2 | IC13.12 22.86,118.11 21.59,116.84 21.59,74.93 20.95,74.3 20.95,24.77 22.23,23.5 IC34.8 | IC45.17 276.86,85.09 277.5,84.45 277.5,78.11 278.13,77.47 281.94,77.47 281.94,88.9 280.67,90.17 280.67,106.68 282.57,108.58 282.57,120.65 283.21,121.28 283.21,122.56 281.94,123.83 RF08B.36
  Bottom 0.254: v52.07,121.92 25.4,121.92 23.5,120.02 IC13.12 | v68.58,27.94 67.31,29.21 42.55,29.21 41.27,27.94 RS08.36 40.01,27.94 39.37,27.94 39.37,24.77 38.73,24.13 25.4,24.13 24.13,22.86 IC34.8 21.59,22.86 18.41,22.86 v15.88,20.32 | IC43.17 277.5,22.23 299.08,22.23 304.8,27.94 304.8,60.33 279.4,60.33 278.13,59.05 278.13,57.15 280.04,57.15 281.31,58.42 RF08A.36 | IC48.1 55.88,163.83 60.96,158.75 130.81,158.75 131.44,159.38 143.51,159.38 144.78,158.12 222.25,158.12 223.52,159.38 227.33,159.38 229.24,157.48 248.92,157.48 250.19,158.75 251.46,157.48 251.46,154.94 245.75,154.94 244.47,153.67 SV3.2
DIO01  (via drill 0.61)  (3 unrouted)
  Top 0.254: v75.56,16.51 75.56,18.41 74.93,19.05 75.56,19.68 75.56,23.5 74.3,24.77 IC35.14 | v24.77,13.34 24.77,26.04 23.5,27.3 IC34.6 | IC13.11 26.04,120.02 29.21,123.19 29.21,125.73 27.3,127.64 7.62,127.64 7.62,26.04 12.06,21.59 17.14,21.59 17.14,12.7 15.24,10.79 SV1.4 | RF08A.37 284.48,55.24 284.48,44.45 280.67,40.64 280.67,24.13 282.57,22.23 282.57,3.17 276.23,3.17 274.32,5.08 IC43.15 | IC45.15 274.95,70.48 276.23,69.22 283.21,69.22 283.21,120.02 284.48,121.28 RF08B.37 | v122.56,164.47 130.18,156.84 143.51,156.84 143.51,177.16 151.13,184.78 v151.13,189.23 | v247.65,191.13 247.65,155.57 246.38,154.31 SV3.4
  Bottom 0.254: IC13.11 26.04,120.02 27.3,121.28 51.44,121.28 52.7,120.02 IC14.11 | IC34.6 24.13,27.94 25.4,26.67 36.2,26.67 37.47,25.4 RS08.37 | v75.56,16.51 72.39,13.34 41.27,13.34 40.64,12.7 24.77,12.7 | 24.77,12.7 19.68,12.7 19.05,13.34 17.78,13.34 15.24,10.79 SV1.4 | 24.77,12.7 v24.77,13.34 | v122.56,164.47 121.92,163.83 111.12,163.83 107.95,167 69.85,167 69.85,163.83 69.22,163.19 62.87,163.19 61.59,164.47 IC48.3 | v151.13,189.23 151.76,189.87 191.13,189.87 191.77,189.23 194.31,191.77 211.46,191.77 212.09,191.13 v247.65,191.13
DIO02  (via drill 0.61)  (3 unrouted)
  Top 0.254: v76.83,30.48 v76.83,41.91 76.2,42.55 76.2,73.66 74.93,74.93 74.93,81.28 v71.75,84.45 | v36.2,41.91 35.56,41.27 v35.56,29.21 | v26.04,29.21 26.04,29.84 23.5,32.38 IC34.4 | v17.78,30.48 17.78,10.79 SV1.6 | v59.05,84.45 59.69,85.09 59.69,114.3 55.88,118.11 IC14.10 | RF08A.35 281.94,56.52 281.94,57.15 285.12,57.15 285.75,56.52 285.75,55.24 285.12,54.61 285.12,43.81 283.21,41.91 283.21,2.54 274.32,2.54 271.78,5.08 IC43.14 | v280.04,84.45 280.04,107.31 281.94,109.22 281.94,121.28 RF08B.35 | v248.92,161.29 248.92,154.31 SV3.6
  Bottom 0.254: IC13.10 28.57,118.75 31.11,116.2 46.35,116.2 46.99,116.84 54.61,116.84 55.88,118.11 IC14.10 | v76.83,30.48 74.93,30.48 IC35.16 | v36.2,41.91 v76.83,41.91 | RS08.35 37.47,27.94 36.83,27.94 v35.56,29.21 v26.04,29.21 | v17.78,30.48 20.32,33.02 21.59,33.02 IC34.4 | v71.75,84.45 v59.05,84.45 | v280.04,84.45 271.78,84.45 271.78,72.39 IC45.14 | v248.92,161.29 227.97,161.29 227.33,160.66 226.06,160.66 225.43,161.29 212.72,161.29 210.19,158.75 159.38,158.75 156.84,161.29 144.15,161.29 143.51,160.66 132.08,160.66 131.44,161.29 106.05,161.29 105.41,160.66 104.78,161.29 59.69,161.29 59.69,166.37 60.33,167 64.14,167 65.41,165.74 IC48.5
DIO03  (via drill 0.61)  (3 unrouted)
  Top 0.254: 25.4,35.56 26.04,34.92 v26.04,33.02 | 25.4,35.56 23.5,37.47 IC34.2 | v68.58,31.75 72.39,35.56 IC35.18 | v19.68,38.1 20.32,37.47 20.32,10.79 SV1.8 | 25.4,35.56 25.4,64.77 26.67,66.04 26.67,114.3 30.48,118.11 IC13.9 | RF08A.33 279.4,55.24 281.31,53.34 281.31,42.55 280.04,41.27 280.04,18.41 281.31,17.14 281.31,12.06 279.4,10.16 279.4,4.45 276.23,4.45 275.59,5.08 275.59,7.62 274.95,8.26 271.14,8.26 269.88,6.99 IC43.13 | IC45.13 269.88,70.48 271.78,68.58 298.45,68.58 298.45,114.94 287.02,126.36 278.13,126.36 278.13,123.83 279.4,122.56 RF08B.33 | v131.44,158.12 125.09,164.47 IC50.1 | v250.19,157.48 251.46,156.21 251.46,154.31 SV3.8
  Bottom 0.254: IC13.9 31.11,118.75 33.02,116.84 45.72,116.84 46.35,117.47 53.98,117.47 54.61,118.11 54.61,121.28 56.52,121.28 57.78,120.02 IC14.9 | v26.04,33.02 27.3,31.75 33.02,31.75 34.29,30.48 37.47,30.48 RS08.33 38.73,30.48 40.01,31.75 v68.58,31.75 | v19.68,38.1 21.59,38.1 IC34.2 | v131.44,158.12 132.72,156.84 249.56,156.84 v250.19,157.48
DIO04  (via drill 0.61)  (3 unrouted)
  Top 0.254: SV1.10 22.86,9.53 24.13,8.26 24.13,6.99 25.4,5.71 39.37,5.71 39.37,19.68 41.91,22.23 v41.91,36.83 41.91,41.27 40.64,42.55 RS08.24 | v70.48,68.58 69.85,69.22 69.85,105.41 75.56,111.12 IC15.2 | v52.7,36.83 53.34,37.47 53.34,62.23 54.61,63.5 v54.61,67.31 | RF08A.24 266.06,58.42 265.43,57.78 265.43,53.98 266.7,52.7 266.7,46.99 IC42.21 | IC39.21 266.7,113.03 265.43,114.3 265.43,122.56 266.7,123.83 RF08B.24 | v219.71,171.45 219.71,174.62 212.09,182.25 212.09,196.22 170.18,196.22 165.74,191.77 147.32,191.77 138.43,182.88 138.43,179.71 133.99,179.71 133.35,180.34 133.35,183.51 128.91,183.51 128.27,182.88 128.27,167.64 129.54,166.37 IC50.3 | v253.37,172.72 254,172.09 254,154.31 SV3.10
  Bottom 0.254: IC26.17 31.75,66.04 32.38,66.67 33.66,66.67 34.29,67.31 v54.61,67.31 63.5,67.31 64.77,68.58 IC28.3 67.31,68.58 v70.48,68.58 | v41.91,36.83 v52.7,36.83 | v219.71,171.45 219.71,173.99 252.09,173.99 v253.37,172.72
DIO05  (via drill 0.61)  (3 unrouted)
  Top 0.254: v44.45,11.43 v44.45,40.64 v44.45,62.23 | v69.22,63.5 69.22,106.05 73.66,110.49 IC15.1 | RF08A.26 268.61,58.42 267.97,57.78 267.97,53.98 269.24,52.7 IC42.20 | IC39.20 269.24,113.03 267.97,114.3 267.97,122.56 269.24,123.83 RF08B.26 | v187.32,167 188.59,168.91 v188.59,170.81 | v250.19,168.28 250.19,173.35 250.82,173.99 254.63,173.99 254.63,156.21 256.54,154.31 SV3.12
  Bottom 0.254: v44.45,11.43 27.3,11.43 26.04,10.16 SV1.12 | v44.45,40.64 RS08.26 | IC26.15 31.75,60.96 33.02,62.23 v44.45,62.23 63.5,62.23 64.77,63.5 IC28.5 v69.22,63.5 | v187.32,167 136.53,167 IC50.5 | v188.59,170.81 189.23,170.18 205.1,170.18 205.74,170.81 210.82,170.81 213.36,168.28 214,168.28 214.63,167.64 249.56,167.64 v250.19,168.28
DIO06  (via drill 0.61)  (3 unrouted)
  Top 0.254: RS08.28 40.64,38.73 39.37,40.01 39.37,46.35 38.73,46.99 37.47,46.99 35.56,48.9 35.56,54.61 v34.29,55.88 34.29,57.78 v36.2,59.69 | v62.87,59.69 62.87,73.03 65.41,75.56 65.41,126.36 69.22,126.36 69.85,125.73 69.85,123.19 72.39,120.65 72.39,117.47 74.3,117.47 75.56,118.75 IC15.13 | v28.57,39.37 28.57,11.43 27.94,10.79 SV1.14 | RF08A.28 271.14,58.42 270.51,57.78 270.51,53.98 271.78,52.7 271.78,46.99 IC42.19 | IC39.19 271.78,113.03 270.51,114.3 270.51,122.56 271.78,123.83 RF08B.28 | v196.85,160.02 193.04,163.83 IC52.1 | v208.28,160.66 208.91,161.29 208.91,163.19 209.55,163.83 209.55,170.18 213.36,173.99 v213.36,179.71 | v253.37,179.71 257.18,175.9 257.18,161.93 258.44,160.66 258.44,153.67 SV3.14
  Bottom 0.254: v34.29,55.88 31.75,55.88 IC26.13 | v36.2,59.69 v62.87,59.69 63.5,59.69 64.77,58.42 IC28.7 | v28.57,39.37 38.73,39.37 40.01,38.1 RS08.28 | v196.85,160.02 197.49,159.38 207.01,159.38 v208.28,160.66 | v213.36,179.71 214,179.07 252.73,179.07 v253.37,179.71
DIO07  (via drill 0.61)  (3 unrouted)
  Top 0.254: v77.47,54.61 76.83,55.24 76.83,63.5 77.47,64.14 77.47,116.84 78.74,118.11 IC15.12 | SV1.16 30.48,10.79 31.75,12.06 31.75,16.51 32.38,17.14 32.38,41.27 31.11,42.55 31.11,50.16 IC26.11 | v45.72,52.07 v45.72,35.56 | RF08A.30 273.69,58.42 273.05,57.78 273.05,53.98 274.32,52.7 274.32,46.99 IC42.18 | IC39.18 274.32,113.03 273.05,114.3 273.05,122.56 274.32,123.83 RF08B.30 | v235.59,147.96 235.59,160.02 234.31,160.02 233.04,158.75 233.04,156.84 201.29,156.84 199.39,158.75 199.39,162.56 198.12,163.83 IC52.3
  Bottom 0.254: IC26.11 31.75,50.8 33.02,52.07 v45.72,52.07 57.78,52.07 59.05,53.34 64.77,53.34 IC28.9 67.31,53.34 68.58,53.34 69.85,54.61 v77.47,54.61 | v45.72,35.56 41.27,35.56 RS08.30 | v235.59,147.96 265.43,147.96 267.97,150.5 267.97,152.4 263.52,152.4 262.25,153.67 SV3.16
DIO08  (via drill 0.61)  (3 unrouted)
  Top 0.254: v43.18,54.61 v43.18,49.53 v43.18,33.02 43.18,22.23 41.91,20.95 41.91,15.24 v40.64,13.97 | v69.22,117.47 68.58,116.84 68.58,64.14 67.94,63.5 67.94,60.96 70.48,58.42 v70.48,52.07 | SV1.18 v33.02,13.97 | RF08A.32 276.23,58.42 275.59,57.78 275.59,53.98 276.86,52.7 IC42.17 | IC39.17 276.86,113.03 275.59,114.3 275.59,122.56 276.86,123.83 RF08B.32 | v212.09,163.83 214.63,166.37 v214.63,168.91 | v262.89,170.81 262.89,155.57 264.16,154.31 SV3.18
  Bottom 0.254: v43.18,54.61 29.21,54.61 27.94,55.88 IC26.8 | v43.18,33.02 RS08.32 | v43.18,49.53 48.26,49.53 48.9,48.9 49.53,48.9 50.8,50.16 57.15,50.16 59.05,52.07 v70.48,52.07 71.12,52.07 72.39,53.34 IC28.12 | v69.22,117.47 69.85,116.84 78.74,116.84 IC15.11 | v33.02,13.97 v40.64,13.97 | v212.09,163.83 210.19,163.83 209.55,163.19 203.2,163.19 IC52.5 | v214.63,168.91 215.26,168.28 248.92,168.28 251.46,170.81 v262.89,170.81
DIO09  (via drill 0.61)  (3 unrouted)
  Top 0.254: v27.3,33.02 27.3,29.21 26.67,28.57 26.67,6.35 36.2,6.35 36.83,6.99 36.83,8.26 35.56,9.53 SV1.20 | v78.11,59.69 78.11,62.23 82.55,66.67 82.55,116.84 83.82,118.11 IC15.10 | v18.41,36.83 17.14,38.1 v17.14,59.05 | RF08A.29 274.95,55.88 274.95,47.62 275.59,46.99 275.59,43.81 274.32,42.55 274.32,31.75 IC42.15 | IC39.15 274.32,97.79 275.59,99.06 275.59,113.03 274.32,114.3 274.32,121.28 RF08B.29 | v261.62,158.12 261.62,163.83 IC54.1
  Bottom 0.254: v27.3,33.02 28.57,34.29 32.38,34.29 | 32.38,34.29 35.56,34.29 36.83,35.56 37.47,35.56 RS08.29 | v78.11,59.69 76.83,58.42 74.93,58.42 IC28.14 72.39,58.42 71.12,58.42 69.85,57.15 37.47,57.15 34.92,59.69 29.21,59.69 28.57,60.33 24.77,60.33 24.13,60.96 IC26.6 21.59,60.96 19.05,60.96 v17.14,59.05 | 32.38,34.29 32.38,36.83 v18.41,36.83 | v261.62,158.12 266.06,153.67 SV3.20
DIO10  (via drill 0.61)  (3 unrouted)
  Top 0.254: v19.68,66.04 20.32,65.41 20.32,46.35 v19.68,45.72 | v35.56,45.72 36.83,44.45 36.83,42.55 37.47,41.91 36.83,41.27 36.83,40.01 | 36.83,40.01 38.1,38.73 RS08.27 | v67.31,45.09 71.75,49.53 71.75,61.59 73.03,62.87 IC28.16 | v85.09,84.45 85.09,116.84 86.36,118.11 IC15.9 | v80.64,83.19 78.11,80.64 v78.11,63.5 | 36.83,40.01 36.83,22.23 37.47,21.59 37.47,11.43 38.1,10.79 SV1.22 | RF08A.27 272.42,55.88 272.42,47.62 273.05,46.99 273.05,43.81 271.78,42.55 271.78,31.75 IC42.14 | IC39.14 271.78,97.79 273.05,99.06 273.05,113.03 271.78,114.3 271.78,121.28 RF08B.27 | v266.7,156.84 266.7,163.83 IC54.3
  Bottom 0.254: v19.68,66.04 21.59,66.04 IC26.4 | v19.68,45.72 v35.56,45.72 36.83,44.45 41.27,44.45 41.91,43.81 66.04,43.81 v67.31,45.09 | v85.09,84.45 83.82,83.19 v80.64,83.19 | v78.11,63.5 74.93,63.5 IC28.16 | v266.7,156.84 269.24,154.31 SV3.22
DIO11  (via drill 0.61)  (3 unrouted)
  Top 0.254: 33.02,64.77 33.02,52.07 34.29,50.8 v34.29,42.55 | 33.02,64.77 v33.02,67.94 | v70.48,66.04 70.48,66.67 72.39,68.58 IC28.18 73.03,69.22 70.48,71.75 70.48,89.53 72.39,91.44 v72.39,99.06 | 33.02,64.77 v33.66,64.77 | v90.17,99.69 90.17,116.84 88.9,118.11 IC15.8 | v46.99,38.1 46.99,6.35 42.55,6.35 41.91,6.99 41.91,8.26 40.64,9.53 SV1.24 | RF08A.25 269.88,55.88 269.88,47.62 270.51,46.99 270.51,43.81 269.24,42.55 269.24,31.75 IC42.13 | IC39.13 269.24,97.79 270.51,99.06 270.51,113.03 269.24,114.3 269.24,121.28 RF08B.25 | IC54.5 271.78,163.83 271.78,154.31 SV3.24
  Bottom 0.254: v33.02,67.94 32.38,67.31 27.94,67.31 24.13,71.12 IC26.2 | v34.29,42.55 36.2,40.64 37.47,40.64 RS08.25 38.73,40.64 40.01,39.37 45.72,39.37 v46.99,38.1 | v70.48,66.04 69.22,64.77 v33.66,64.77 | v90.17,99.69 89.53,99.06 v72.39,99.06
DIOEVEN  (via drill 0.61)  (2 unrouted)
  Top 0.254: v45.72,30.48 v45.72,26.67 | v60.33,114.94 62.23,113.03 62.23,92.08 60.33,90.17 60.33,40.64 61.59,39.37 61.59,23.5 64.77,20.32 IC35.9 | v287.02,88.9 285.75,90.17 285.75,125.09 285.12,125.73 279.4,125.73 279.4,125.09 RF08B.34
  Bottom 0.254: v45.72,26.67 59.69,26.67 65.41,20.95 IC35.9 | v45.72,30.48 41.27,30.48 RS08.34 | v60.33,114.94 59.69,114.3 46.99,114.3 46.35,114.94 24.77,114.94 20.95,118.75 IC13.13 | IC43.18 274.95,22.23 276.23,23.5 286.38,23.5 287.02,22.86 298.45,22.86 304.17,28.57 304.17,59.69 281.31,59.69 280.04,58.42 RF08A.34 | v287.02,88.9 276.86,88.9 274.95,87 IC45.18
DMA00  (via drill 0.61)  (3 unrouted)
  Top 0.254: v137.16,11.43 135.89,10.16 DMA0-3.7 133.99,9.53 128.91,4.45 v128.91,3.17 | 46.99,54.61 v45.72,53.34 | 46.99,54.61 v46.99,86.36 | v43.18,90.17 43.18,87 SV2.1 | v73.66,6.99 60.33,20.32 v60.33,39.37 | v47.62,39.37 46.99,40.01 46.99,54.61 | IC43.25 256.54,22.86 256.54,27.3 255.27,28.57 255.27,31.75 256.54,33.02 256.54,44.45 IC42.25 256.54,46.99 256.54,52.7 255.27,53.98 255.27,57.78 255.91,58.42 RF08A.16 | IC45.25 256.54,87.63 255.27,88.9 255.27,107.95 256.54,109.22 256.54,110.49 IC39.25 256.54,113.03 255.27,114.3 255.27,122.56 256.54,123.83 RF08B.16 | v121.28,189.87 121.28,191.13 71.75,191.13 69.22,188.59 IC47.9 | v191.77,190.5 v194.31,190.5 | v270.51,191.13 270.51,182.88 271.78,181.61 IC53.5 | v285.75,163.83 285.75,188.59 287.02,189.87 SV4.24
  Bottom 0.254: v137.16,11.43 162.56,11.43 163.83,12.7 IC38.8 | v45.72,53.34 41.27,53.34 RS08.16 | v46.99,86.36 43.81,86.36 SV2.1 | v43.18,90.17 35.56,90.17 33.66,88.27 19.05,88.27 19.05,85.72 18.41,85.09 17.14,85.09 15.88,83.82 SV2.24 | v128.91,3.17 128.27,2.54 96.52,2.54 93.98,5.08 78.11,5.08 77.47,4.45 76.2,4.45 v73.66,6.99 | v60.33,39.37 v47.62,39.37 | v121.28,189.87 123.83,187.32 135.25,187.32 135.89,187.96 135.89,191.13 166.37,191.13 167,190.5 v191.77,190.5 | v194.31,190.5 194.94,189.87 196.22,189.87 196.85,189.23 197.49,189.87 243.84,189.87 244.47,189.23 246.38,189.23 260.35,189.23 261.62,190.5 270.51,190.5 | 270.51,190.5 286.38,190.5 SV4.24 | 270.51,190.5 v270.51,191.13 | v285.75,163.83 287.65,163.83 288.93,162.56 SV4.1
DMA01  (via drill 0.61)  (3 unrouted)
  Top 0.254: 40.64,80.64 39.37,79.38 39.37,50.16 40.64,48.9 RS08.20 | 40.64,80.64 40.64,81.92 39.37,83.19 39.37,84.45 40.64,85.72 SV2.3 | v92.71,11.43 90.17,13.97 v90.17,44.45 | v57.78,79.38 v57.78,45.72 | 40.64,80.64 v41.91,79.38 | IC43.23 261.62,22.86 261.62,27.3 260.35,28.57 260.35,31.75 261.62,33.02 261.62,44.45 IC42.23 261.62,46.99 261.62,52.7 260.35,53.98 260.35,57.78 260.99,58.42 RF08A.20 | IC45.23 261.62,87.63 260.99,88.27 260.99,94.61 260.35,95.25 260.35,106.05 261.62,107.31 261.62,110.49 IC39.23 261.62,113.03 260.35,114.3 260.35,122.56 261.62,123.83 RF08B.20 | v80.01,186.06 65.41,186.06 64.14,187.32 IC47.11 | v138.43,184.15 146.05,191.77 146.05,193.68 149.22,196.85 280.67,196.85 280.67,173.99 281.94,172.72 280.67,171.45 280.67,166.37 285.75,161.29 288.29,161.29 288.29,163.19 289.56,164.47 SV4.3
  Bottom 0.254: IC38.6 163.83,17.78 162.56,16.51 139.7,16.51 135.89,12.7 DMA0-3.6 133.35,12.7 110.49,12.7 109.22,11.43 v92.71,11.43 | v90.17,44.45 69.22,44.45 67.31,46.35 58.42,46.35 v57.78,45.72 | v41.91,79.38 v57.78,79.38 | v80.01,186.06 87.63,178.44 136.53,178.44 138.43,180.34 v138.43,184.15
DMA02  (via drill 0.61)  (3 unrouted)
  Top 0.254: v49.53,55.88 v49.53,88.9 | v40.64,91.44 38.1,88.9 SV2.5 | v132.72,19.05 132.72,20.95 DMA0-3.2 | v84.45,20.32 80.64,24.13 v80.64,57.15 | IC43.26 254,27.3 252.73,28.57 252.73,31.75 254,33.02 IC42.26 254,52.7 252.73,53.98 252.73,57.78 253.37,58.42 RF08A.14 | IC45.26 254,87.63 252.73,88.9 252.73,109.22 254,110.49 IC39.26 254,113.03 252.73,114.3 252.73,122.56 254,123.83 RF08B.14 | v120.02,165.1 120.02,157.48 79.38,157.48 77.47,159.38 77.47,161.29 40.01,161.29 29.21,172.09 29.21,175.9 43.18,189.87 43.18,191.13 57.78,191.13 57.78,189.87 58.42,189.23 IC47.13
  Bottom 0.254: DMA0-3.2 135.89,22.86 137.16,21.59 162.56,21.59 163.83,22.86 IC38.4 | v49.53,88.9 46.99,91.44 v40.64,91.44 | RS08.14 v49.53,55.88 50.8,54.61 68.58,54.61 71.12,57.15 v80.64,57.15 | v132.72,19.05 132.08,18.41 94.61,18.41 92.71,20.32 v84.45,20.32 | v120.02,165.1 121.92,167 135.25,167 136.53,168.28 204.47,168.28 205.1,167.64 213.36,167.64 214,167 252.09,167 252.73,167.64 283.85,167.64 285.12,166.37 287.65,166.37 288.93,167.64 SV4.5
DMA03  (via drill 0.61)  (3 unrouted)
  Top 0.254: v139.06,29.21 139.06,24.77 135.25,20.95 DMA0-3.3 | v159.38,30.48 v161.93,27.94 | v48.26,85.09 v48.26,58.42 v48.26,48.26 | v93.34,21.59 90.81,24.13 90.81,43.81 91.44,44.45 91.44,45.72 v90.17,46.99 | IC43.27 251.46,22.86 251.46,27.3 250.19,28.57 250.19,31.75 251.46,33.02 251.46,44.45 IC42.27 251.46,46.99 251.46,52.7 250.19,53.98 250.19,57.78 250.82,58.42 RF08A.12 | IC45.27 251.46,87.63 250.82,88.27 250.82,94.61 250.19,95.25 250.19,98.42 251.46,99.69 251.46,110.49 IC39.27 251.46,113.03 250.19,114.3 250.19,122.56 251.46,123.83 RF08B.12 | v183.51,186.06 189.23,180.34 189.23,173.35 193.68,168.91 193.68,167 194.31,166.37 194.31,163.83 194.94,163.19 196.85,163.19 196.85,168.91 199.39,171.45 199.39,173.99 201.93,176.53 201.93,184.15 204.47,186.69 204.47,189.23 205.1,189.87 209.55,189.87 v209.55,175.26
  Bottom 0.254: v139.06,29.21 140.34,30.48 v159.38,30.48 | v161.93,27.94 163.83,27.94 IC38.2 | v48.26,85.09 37.47,85.09 36.2,86.36 SV2.7 | v48.26,58.42 41.27,58.42 RS08.12 | v93.34,21.59 95.89,19.05 125.09,19.05 126.36,20.32 133.35,20.32 DMA0-3.3 | v90.17,46.99 87.63,49.53 80.01,49.53 78.11,47.62 52.7,47.62 52.07,48.26 v48.26,48.26 | v183.51,186.06 140.34,186.06 137.79,188.59 IC49.9 | v209.55,175.26 210.19,175.9 280.67,175.9 281.31,175.26 285.12,175.26 286.38,176.53 287.65,176.53 288.29,175.9 288.29,170.81 289.56,170.81 SV4.7
DMA04  (via drill 0.61)  (3 unrouted)
  Top 0.254: v35.56,60.96 35.56,78.11 34.29,79.38 v34.29,82.55 | v124.46,80.01 124.46,73.03 125.73,71.75 v125.73,64.77 | v138.43,61.59 137.79,60.96 137.79,50.16 135.89,48.26 132.72,48.26 132.72,46.35 133.99,45.09 DMA4-7.7 | IC43.5 248.92,7.62 248.92,18.41 250.19,19.68 250.19,22.86 249.56,23.5 249.56,29.84 IC42.5 249.56,31.11 249.56,32.38 250.19,33.02 250.19,46.99 249.56,47.62 249.56,55.88 RF08A.9 | IC45.5 248.92,72.39 250.19,73.66 250.19,93.98 248.92,95.25 IC39.5 248.92,97.79 248.92,98.42 250.19,99.69 250.19,113.03 249.56,113.67 249.56,120.65 248.92,121.28 RF08B.9 | v139.06,196.22 132.72,189.87 IC49.11
  Bottom 0.254: v35.56,60.96 37.47,60.96 RS08.9 | SV2.9 33.02,85.72 34.29,85.72 v34.29,82.55 38.73,78.11 60.96,78.11 64.14,81.28 93.98,81.28 95.89,83.19 97.16,83.19 97.79,82.55 97.79,79.38 120.65,79.38 121.28,80.01 v124.46,80.01 | DMA4-7.7 135.89,44.45 139.7,48.26 153.03,48.26 155.57,45.72 160.66,45.72 161.93,46.99 163.83,46.99 IC31.8 | v125.73,64.77 135.25,64.77 v138.43,61.59 | v139.06,196.22 139.7,196.85 290.19,196.85 292.74,194.31 292.74,173.35 289.56,173.35 SV4.9
DMA05  (via drill 0.61)  (3 unrouted)
  Top 0.254: v35.56,79.38 v36.83,78.11 36.83,73.03 36.2,72.39 36.2,61.59 36.83,60.96 36.83,60.33 38.1,59.05 RS08.11 | v138.43,41.91 138.43,43.18 135.25,46.35 DMA4-7.6 | v158.12,40.01 160.02,41.91 160.02,50.8 v161.29,52.07 | v62.23,78.11 61.59,77.47 61.59,44.45 63.5,42.55 v63.5,40.64 | IC43.6 251.46,7.62 251.46,18.41 252.73,19.68 252.73,22.86 252.09,23.5 252.09,29.84 IC42.6 252.09,31.11 252.09,32.38 252.73,33.02 252.73,46.99 252.09,47.62 252.09,55.88 RF08A.11 | IC45.6 251.46,72.39 252.73,73.66 252.73,87.63 251.46,88.9 251.46,95.25 IC39.6 252.09,97.16 252.09,109.86 252.73,110.49 252.73,113.03 252.09,113.67 252.09,120.65 251.46,121.28 RF08B.11 | v128.27,194.31 128.27,191.77 127,190.5 IC49.13
  Bottom 0.254: v35.56,79.38 31.75,83.19 31.75,84.45 30.48,85.72 SV2.11 | v138.43,41.91 140.34,40.01 v158.12,40.01 | v161.29,52.07 163.83,52.07 IC31.6 | v36.83,78.11 37.47,77.47 61.59,77.47 v62.23,78.11 | v63.5,40.64 64.77,39.37 118.75,39.37 123.83,44.45 130.81,44.45 133.35,46.99 DMA4-7.6 | v128.27,194.31 128.91,194.94 171.45,194.94 172.72,196.22 289.56,196.22 292.1,193.68 292.1,175.9 289.56,175.9 SV4.11
DMA06  (via drill 0.61)  (3 unrouted)
  Top 0.254: v19.05,55.88 18.41,56.52 18.41,59.05 16.51,60.96 v16.51,75.56 16.51,80.64 13.97,83.19 13.97,91.44 v14.61,92.08 | v117.47,59.69 116.2,60.96 v116.2,77.47 | v90.81,78.11 91.44,78.74 91.44,93.98 90.17,95.25 90.17,98.42 88.9,99.69 v88.9,100.97 | IC43.7 254,7.62 254,18.41 255.27,19.68 255.27,22.86 254.63,23.5 254.63,29.84 IC42.7 254.63,31.11 254.63,32.38 255.27,33.02 255.27,46.99 254.63,47.62 254.63,55.88 RF08A.13 | IC45.7 254,72.39 255.27,73.66 255.27,87.63 254,88.9 254,95.25 IC39.7 254,97.79 254,107.95 255.27,109.22 255.27,113.03 254.63,113.67 254.63,120.65 254,121.28 RF08B.13 | v207.01,177.16 207.01,185.42 205.74,186.69 IC51.9
  Bottom 0.254: IC31.4 163.83,57.15 162.56,55.88 137.16,55.88 135.89,57.15 DMA4-7.2 133.35,57.15 132.72,57.78 129.54,57.78 127.64,59.69 v117.47,59.69 | v19.05,55.88 20.32,55.88 21.59,57.15 36.2,57.15 37.47,55.88 RS08.13 | v16.51,75.56 24.13,83.19 24.13,85.09 26.04,85.09 27.3,86.36 SV2.13 | v116.2,77.47 115.57,78.11 v90.81,78.11 | v88.9,100.97 88.27,100.33 73.66,100.33 73.03,100.97 61.59,100.97 60.96,101.6 45.09,101.6 41.91,98.42 12.06,98.42 11.43,97.79 11.43,95.89 10.79,95.89 8.26,93.34 8.26,88.27 10.79,88.27 v14.61,92.08 | v207.01,177.16 207.65,177.8 281.31,177.8 282.57,179.07 287.65,179.07 288.93,177.8 SV4.13
DMA07  (via drill 0.61)  (3 unrouted)
  Top 0.254: v137.16,64.14 137.16,57.15 135.25,55.24 DMA4-7.3 | v36.83,49.53 36.83,51.44 38.1,52.7 RS08.15 | v113.67,45.72 117.47,49.53 v117.47,57.15 | v25.4,89.53 25.4,87 SV2.15 | v52.07,46.99 v52.07,92.71 | IC43.8 256.54,7.62 256.54,18.41 257.81,19.68 257.81,22.86 257.18,23.5 257.18,29.84 IC42.8 257.18,31.11 257.18,32.38 257.81,33.02 257.81,46.99 257.18,47.62 257.18,55.88 RF08A.15 | IC45.8 256.54,72.39 257.81,73.66 257.81,87.63 256.54,88.9 256.54,95.25 IC39.8 256.54,97.79 256.54,98.42 257.81,99.69 257.81,113.03 257.18,113.67 257.18,120.65 256.54,121.28 RF08B.15 | v207.65,194.94 201.29,188.59 IC51.11
  Bottom 0.254: v137.16,64.14 138.43,65.41 163.19,65.41 163.83,66.04 173.99,66.04 174.62,65.41 174.62,63.5 167.64,63.5 166.37,62.23 IC31.2 | v36.83,49.53 41.91,49.53 44.45,46.99 v52.07,46.99 88.9,46.99 90.17,45.72 v113.67,45.72 | v117.47,57.15 130.81,57.15 133.35,54.61 DMA4-7.3 | v25.4,89.53 28.57,92.71 v52.07,92.71 | v207.65,194.94 208.28,195.58 288.93,195.58 291.46,193.04 291.46,180.97 289.56,180.97 SV4.15
DMA08  (via drill 0.61)  (3 unrouted)
  Top 0.254: v137.79,83.82 137.79,81.92 DMA8-11.7 | v159.38,85.09 160.66,83.82 v160.66,81.28 | v33.02,50.8 32.38,50.16 v32.38,42.55 | v10.16,41.91 8.89,43.18 v8.89,81.28 | v130.81,80.64 130.18,81.28 v130.18,93.98 | v99.06,93.98 97.79,95.25 v97.79,99.06 | IC43.9 259.08,18.41 260.35,19.68 260.35,22.86 259.71,23.5 259.71,29.84 IC42.9 259.71,31.11 259.71,32.38 260.35,33.02 260.35,46.99 259.71,47.62 259.71,55.88 RF08A.17 | IC45.9 259.08,72.39 260.35,73.66 260.35,93.98 259.08,95.25 IC39.9 259.08,106.05 260.35,107.31 260.35,113.03 259.71,113.67 259.71,120.65 259.08,121.28 RF08B.17 | IC51.13 v195.58,194.31 | v288.29,191.77 288.29,184.78 289.56,183.51 SV4.17
  Bottom 0.254: v137.79,83.82 139.06,85.09 v159.38,85.09 | v160.66,81.28 IC24.8 | v32.38,42.55 31.75,41.91 v10.16,41.91 | 9.53,81.92 10.16,82.55 20.95,82.55 21.59,83.19 21.59,86.36 SV2.17 | v8.89,81.28 9.53,81.92 | v33.02,50.8 RS08.17 | v130.81,80.64 131.44,80.64 133.35,78.74 DMA8-11.7 | v99.06,93.98 v130.18,93.98 | v97.79,99.06 94.61,102.23 88.9,102.23 87.63,100.97 74.3,100.97 73.66,101.6 62.23,101.6 61.59,102.23 44.45,102.23 41.27,99.06 9.53,99.06 5.08,94.61 5.08,81.92 9.53,81.92 | v195.58,194.31 196.22,193.68 210.82,193.68 212.09,194.94 283.21,194.94 286.38,191.77 v288.29,191.77
DMA09  (via drill 0.61)  (3 unrouted)
  Top 0.254: v136.53,85.09 136.53,83.19 135.25,81.92 DMA8-11.6 | v42.55,63.5 41.91,62.87 41.91,46.99 40.01,46.99 38.73,48.26 RS08.19 | v45.09,63.5 46.35,64.77 46.35,85.72 45.72,86.36 45.72,87 v46.35,87.63 | IC43.10 261.62,7.62 261.62,18.41 262.89,19.68 262.89,22.86 262.25,23.5 262.25,29.84 IC42.10 262.25,31.11 262.25,32.38 262.89,33.02 262.89,55.24 262.25,55.88 RF08A.19 | IC45.10 261.62,72.39 262.89,73.66 262.89,88.27 261.62,89.53 261.62,95.25 IC39.10 261.62,97.79 262.89,99.06 262.89,120.02 261.62,121.28 RF08B.19 | v278.13,184.15 274.95,187.32 IC53.9
  Bottom 0.254: IC24.6 163.83,86.36 162.56,86.36 161.29,87.63 139.06,87.63 v136.53,85.09 128.27,85.09 127,86.36 52.07,86.36 50.8,87.63 v46.35,87.63 20.95,87.63 20.32,87 SV2.19 | v42.55,63.5 v45.09,63.5 | v278.13,184.15 287.65,184.15 288.93,185.42 SV4.19
DMA10  (via drill 0.61)  (3 unrouted)
  Top 0.254: v6.35,46.99 v6.35,83.19 | v126.36,91.44 125.73,90.81 v125.73,84.45 | v50.8,81.92 v50.8,45.72 | 265.43,29.21 264.8,29.84 IC42.11 | 265.43,29.21 265.43,19.68 264.16,18.41 264.16,7.62 IC43.11 | 265.43,29.21 265.43,46.99 264.16,48.26 264.16,55.24 RF08A.21 | 265.43,93.98 265.43,73.66 264.16,72.39 IC45.11 | 265.43,93.98 264.16,95.25 IC39.11 | 265.43,93.98 265.43,113.03 264.8,113.67 264.8,120.65 264.16,121.28 RF08B.21
  Bottom 0.254: IC24.4 163.83,91.44 162.56,90.17 137.16,90.17 135.89,91.44 DMA8-11.2 133.35,91.44 v126.36,91.44 | 36.2,46.99 37.47,45.72 RS08.21 | 36.2,46.99 v6.35,46.99 | v6.35,83.19 8.26,85.09 15.88,85.09 17.14,86.36 SV2.21 | v125.73,84.45 100.97,84.45 100.33,83.82 99.06,83.82 97.16,85.72 54.61,85.72 v50.8,81.92 | v50.8,45.72 50.16,46.35 41.91,46.35 41.27,46.99 36.2,46.99 | IC53.11 269.88,187.32 271.14,186.06 281.31,186.06 281.94,186.69 287.65,186.69 288.93,187.96 SV4.21
DMA11  (via drill 0.61)  (3 unrouted)
  Top 0.254: v161.93,96.52 v161.93,99.06 | DMA8-11.3 135.25,89.53 137.16,91.44 v137.16,98.42 130.18,105.41 130.18,108.58 128.27,110.49 128.27,120.02 v125.09,123.19 | v27.94,44.45 27.3,45.09 27.3,50.16 27.94,50.8 v27.94,58.42 | v19.05,59.69 19.05,65.41 18.41,66.04 18.41,82.55 19.05,83.19 19.05,84.45 18.41,85.09 16.51,85.09 | 16.51,85.09 15.24,85.09 15.24,85.72 SV2.23 | v16.51,126.36 16.51,85.09 | IC43.12 266.7,7.62 266.7,19.05 267.97,20.32 267.97,22.86 266.7,24.13 266.7,29.21 IC42.12 266.7,31.75 266.7,42.55 267.97,43.81 267.97,46.99 267.33,47.62 267.33,55.88 RF08A.23 | 267.97,93.98 267.97,73.66 266.7,72.39 IC45.12 | 267.97,93.98 266.7,95.25 IC39.12 | 267.97,93.98 267.97,113.03 267.33,113.67 267.33,120.65 266.7,121.28 RF08B.23
  Bottom 0.254: v137.16,98.42 161.29,98.42 v161.93,99.06 | v161.93,96.52 163.83,96.52 IC24.2 | v27.94,44.45 29.84,44.45 30.48,43.81 36.83,43.81 37.47,43.18 RS08.23 | v27.94,58.42 26.67,59.69 v19.05,59.69 | v125.09,123.19 124.46,122.56 93.34,122.56 92.71,121.92 63.5,121.92 59.05,126.36 v16.51,126.36 | IC53.13 264.8,188.59 266.06,189.87 285.75,189.87 286.38,189.23 287.65,189.23 288.93,190.5 SV4.23
DMA-IN\  (via drill 0.61)
  Top 0.254: IC34.1 22.86,41.27 22.86,48.26 24.77,50.16 24.77,71.75 23.5,73.03 IC26.1 22.86,74.3 22.86,76.83 24.13,78.11 24.13,109.22 25.4,110.49 IC13.4 | v19.05,12.06 19.68,12.7 19.68,36.83 v18.41,38.1
  Bottom 0.254: IC26.19 29.21,71.12 28.57,71.75 26.04,71.75 24.13,73.66 IC26.1 | v19.05,12.06 41.27,12.06 41.91,12.7 76.83,12.7 77.47,13.34 87,13.34 88.27,14.61 IC41.12 | v18.41,38.1 20.95,40.64 21.59,40.64 IC34.1
DMA-OUT\  (via drill 0.61)
  Top 0.254: IC35.1 65.41,41.27 64.14,42.55 64.14,71.75 65.41,73.03 IC28.1 | 75.56,40.01 74.3,38.73 IC35.19 | 75.56,40.01 75.56,69.22 74.3,70.48 IC28.19 | v92.71,19.05 95.89,15.88 IC41.9 | v76.2,19.05 76.2,29.84 75.56,30.48 75.56,40.01
  Bottom 0.254: v76.2,19.05 v92.71,19.05 | IC28.1 67.31,73.66 69.85,71.12 72.39,71.12 IC28.19
DONE  (via drill 0.61)  (1 unrouted)
  Top 0.254: v152.4,26.67 152.4,22.86 150.5,20.95 IC40.2 | v177.8,26.67 178.44,26.04 178.44,8.26 184.15,2.54 194.31,2.54 194.31,113.03 198.12,116.84 198.12,118.11 IC11.9 | v57.15,6.99 v64.77,14.61 | v132.08,15.24 133.35,13.97 139.7,13.97 139.7,10.16 140.97,8.89 145.41,8.89 145.41,19.68 v146.05,20.32 | IC54.13 264.8,173.35 266.06,174.62 270.51,174.62 270.51,153.03 271.78,151.76 SV3.23
  Bottom 0.254: v152.4,26.67 v177.8,26.67 | v57.15,6.99 50.8,6.99 50.16,6.35 42.55,6.35 41.27,7.62 SV1.23 | v64.77,14.61 66.67,16.51 69.85,16.51 72.39,19.05 74.93,19.05 76.2,17.78 129.54,17.78 v132.08,15.24 | v146.05,20.32 148.59,20.32 IC40.2
DRV01\  (via drill 0.61)  (2 unrouted)
  Top 0.254: v52.7,24.13 52.7,2.54 87.63,2.54 88.9,3.81 86.36,6.35 IC41.4
  Bottom 0.254: v52.7,24.13 42.55,24.13 41.27,25.4 RS08.38 | RF08A.38 284.48,57.78 285.12,57.15 288.29,57.15 288.93,56.52 J1.1 | RF08B.38 285.12,124.46 286.38,123.19 288.29,123.19 288.93,122.56 J15.1
DRV23\  (via drill 0.61)  (2 unrouted)
  Top 0.254: v93.98,2.54 93.98,6.35 IC41.7 | v53.98,5.71 53.98,44.45 v54.61,45.09
  Bottom 0.254: v93.98,2.54 57.15,2.54 v53.98,5.71 | v54.61,45.09 53.98,44.45 42.55,44.45 41.27,45.72 RS08.22 | J1.3 288.93,48.9 283.85,53.98 266.7,53.98 265.43,55.24 265.43,57.78 264.16,57.78 RF08A.22 | RF08B.22 264.16,123.83 262.89,122.56 262.89,109.86 277.5,109.86 281.31,113.67 288.93,113.67 J15.3
DRVOK\  (via drill 0.61)  (2 unrouted)
  Top 0.254: IC21.13 80.64,103.5 79.38,103.5 IC21.14 78.74,102.87 80.01,101.6 v80.01,84.45 | v59.05,83.19 59.05,43.81 55.88,40.64 v55.88,22.86
  Bottom 0.254: 43.81,19.05 40.64,22.23 RS08.40 | 43.81,19.05 45.09,17.78 R2.1 | v80.01,84.45 78.74,83.19 v59.05,83.19 | v55.88,22.86 52.07,19.05 43.81,19.05 | D4.A 290.83,58.42 287.65,58.42 RF08A.40 | D8.A 290.83,124.46 287.65,124.46 RF08B.40
DRVSELA\  (4 unrouted)
  Top 0.254: 264.16,44.45 263.52,43.81 263.52,32.38 262.89,31.75 262.89,24.13 264.16,22.86 IC43.22
  Bottom 0.254: 236.85,15.24 262.89,15.24 263.52,15.88 263.52,19.05 264.16,19.68 264.16,20.32 IC43.22 264.8,22.23 269.88,27.3 287.65,27.3 | 287.65,27.3 288.93,26.04 | 301.62,57.78 301.62,27.3 287.65,27.3
DRVSELB\  (4 unrouted)
  Top 0.254: 264.16,110.49 263.52,109.86 263.52,98.42 262.89,97.79 262.89,89.53 264.16,88.27 264.16,87.63 IC45.22
  Bottom 0.254: 300.99,124.46 292.74,116.2 268.61,116.2 264.8,112.39 IC39.22 | 236.85,78.74 242.57,84.45 262.25,84.45 263.52,85.72 IC45.22 264.8,87 271.14,93.34 287.65,93.34 288.93,92.08
EIE  (via drill 0.61)  (1 unrouted)
  Top 0.254: 199.39,8.89 200.03,9.53 INTENB.6 200.66,8.89 200.66,5.71 207.01,5.71 208.28,6.99 208.28,25.4 210.19,27.3 IC37.2 | 199.39,8.89 v197.49,6.99 | v5.08,100.33 5.08,8.89 13.34,8.89 14.61,7.62 SV1.3 | v74.93,94.61 v74.93,106.05 | v136.53,87.63 139.06,85.09 139.06,74.93 138.43,74.3 v138.43,71.75 | v196.22,69.85 196.85,69.22 196.85,46.99 195.58,45.72 195.58,22.86 199.39,19.05 199.39,8.89 | v67.94,168.28 64.14,172.09 IC48.11 | v198.12,177.8 199.39,179.07 v199.39,183.51 | v234.95,184.15 236.85,186.06 242.57,186.06 242.57,175.26 245.11,172.72 245.11,153.03 246.38,151.76 SV3.3
  Bottom 0.254: v197.49,6.99 187.32,6.99 185.42,8.89 160.02,8.89 158.75,10.16 IC40.9 | v5.08,100.33 10.79,106.05 v74.93,106.05 | v74.93,94.61 79.38,90.17 109.22,90.17 110.49,91.44 125.09,91.44 128.27,88.27 132.72,88.27 133.35,87.63 v136.53,87.63 | v138.43,71.75 139.06,71.12 177.8,71.12 178.44,71.75 180.34,71.75 182.25,69.85 v196.22,69.85 | v67.94,168.28 115.57,168.28 118.11,170.81 122.56,170.81 123.19,170.18 133.99,170.18 134.62,170.81 143.51,170.81 146.69,173.99 170.81,173.99 173.99,177.16 197.49,177.16 v198.12,177.8 | v199.39,183.51 200.03,182.88 210.19,182.88 211.46,184.15 v234.95,184.15
ERROR  (via drill 0.61)
  Top 0.254: v170.18,96.52 167.64,93.98 167.64,54.61 168.28,53.98 168.28,53.34 167.64,52.7 167.64,48.9 168.91,47.62 168.91,40.01 169.54,39.37 169.54,35.56 170.18,34.92 170.18,29.21 163.83,29.21 163.19,28.57 163.19,18.41 158.12,13.34 IC40.10 | v180.34,119.38 180.97,118.75 180.97,97.16 181.61,96.52 v181.61,94.61
  Bottom 0.254: v170.18,96.52 171.45,97.79 173.99,97.79 175.9,95.89 179.71,95.89 180.97,94.61 v181.61,94.61 211.46,94.61 212.72,95.89 212.72,98.42 211.46,98.42 IC12.6 | v180.34,119.38 184.78,123.83 IC7.2
EXAD0\  (via drill 0.61)
  Top 0.254: v12.06,88.27 11.43,87.63 11.43,74.3 13.97,71.75 13.97,65.41 12.7,64.14 C35L.34
  Bottom 0.254: v12.06,88.27 17.14,93.34 29.84,93.34 32.38,95.89 IC20.9
EXAD1\  (via drill 0.61)
  Top 0.254: v9.53,89.53 10.16,88.9 10.16,69.22 12.7,66.67 C35L.36
  Bottom 0.254: v9.53,89.53 13.97,93.98 25.4,93.98 27.3,95.89 IC20.7
EXAD2\  (via drill 0.61)
  Top 0.254: v10.79,94.61 10.79,71.12 12.7,69.22 C35L.38
  Bottom 0.254: v10.79,94.61 20.95,94.61 22.23,95.89 IC20.5
F.1  (via drill 0.61)  (1 unrouted)
  Top 0.254: SV2.6 38.1,84.45 36.83,85.72 36.83,101.6 35.56,102.87 IC20.11 35.56,105.41 v35.56,139.06 | IC30.8 210.19,43.81 208.91,45.09 208.91,81.92 210.19,83.19 FIELD.3 210.19,84.45 205.1,89.53 v205.1,130.18 | v70.48,175.9 66.67,179.71 IC47.5 | v152.4,175.9 152.4,176.53 v167.64,192.41 | v278.13,193.68 280.04,191.77 v280.04,172.72
  Bottom 0.254: v35.56,139.06 37.47,140.97 92.71,140.97 93.98,139.7 150.5,139.7 151.76,138.43 153.03,138.43 154.31,139.7 155.57,139.7 156.21,139.06 156.21,134.62 200.66,134.62 v205.1,130.18 | v70.48,175.9 123.83,175.9 124.46,176.53 127,176.53 127.64,175.9 149.86,175.9 v152.4,175.9 | v167.64,192.41 168.28,191.77 190.5,191.77 191.77,193.04 211.46,193.04 212.72,194.31 277.5,194.31 v278.13,193.68 | v280.04,172.72 285.12,167.64 286.38,167.64 SV4.6
F.2  (via drill 0.61)  (1 unrouted)
  Top 0.254: SV2.4 40.64,84.45 41.91,85.72 41.91,99.69 v38.73,102.87 43.18,107.31 v43.18,111.12 | v215.26,41.27 214.63,41.91 v214.63,86.36 v214.63,107.95 | v110.49,107.95 111.76,109.22 113.03,109.22 113.03,102.23 115.57,99.69 119.38,99.69 119.38,108.58 v118.75,109.22 | v151.13,177.16 v162.56,188.59 | v248.92,184.15 250.19,182.88 250.19,179.71 256.54,173.35 v256.54,161.29
  Bottom 0.254: v38.73,102.87 38.1,102.23 32.38,102.23 IC20.13 | v215.26,41.27 IC30.11 | v214.63,86.36 FIELD.2 | v43.18,111.12 44.45,112.39 44.45,113.67 68.58,113.67 72.39,109.86 99.69,109.86 100.97,108.58 107.95,108.58 109.22,107.31 109.86,107.31 v110.49,107.95 | v118.75,109.22 120.02,110.49 128.27,110.49 128.91,109.86 177.16,109.86 179.07,107.95 v214.63,107.95 | v151.13,177.16 60.96,177.16 IC47.3 | v162.56,188.59 163.19,189.23 186.69,189.23 191.13,184.78 196.85,184.78 197.49,185.42 234.95,185.42 236.85,183.51 242.57,183.51 243.21,184.15 v248.92,184.15 | v256.54,161.29 278.13,161.29 278.76,161.93 280.04,161.93 280.67,161.29 285.12,161.29 287.02,159.38 289.56,159.38 290.83,160.66 290.83,163.83 288.93,163.83 287.65,165.1 SV4.4
F.3  (via drill 0.61)  (1 unrouted)
  Top 0.254: v41.27,101.6 44.45,98.42 44.45,95.25 | 44.45,95.25 44.45,85.72 43.18,84.45 SV2.2 | v220.34,77.47 220.34,57.15 217.17,57.15 216.53,56.52 216.53,45.09 IC30.13 215.9,40.64 215.9,24.77 v212.72,21.59 | v43.81,95.25 44.45,95.25 | v71.75,89.53 76.2,85.09 v76.2,76.83 | v106.68,69.85 107.95,68.58 v107.95,28.57 | v62.23,191.13 62.23,186.69 IC47.1 | v281.94,192.41 284.48,189.87 284.48,163.83 285.75,162.56 SV4.2
  Bottom 0.254: v41.27,101.6 27.94,101.6 IC20.15 | v220.34,77.47 213.36,77.47 212.09,76.2 FIELD.6 | v43.81,95.25 44.45,94.61 66.67,94.61 v71.75,89.53 | v76.2,76.83 83.19,69.85 v106.68,69.85 | v107.95,28.57 111.12,25.4 122.56,25.4 123.83,24.13 168.91,24.13 171.45,21.59 v212.72,21.59 | v62.23,191.13 62.87,191.77 167,191.77 167.64,191.13 191.13,191.13 192.41,192.41 212.09,192.41 212.72,191.77 247.01,191.77 247.65,192.41 v281.94,192.41
GND  (3 unrouted)
  Top 0.254: IC14.13 48.26,118.11 48.26,113.03 IC14.2 | IC20.17 20.32,105.41 20.32,110.49 IC13.2 19.68,111.12 18.41,111.12 IC13.1 | IC20.10 35.56,97.79 34.29,99.06 34.29,109.22 33.02,110.49 IC13.7 | IC14.1 45.09,112.39 43.18,112.39 C14.2 | RS08.31 38.1,32.38 39.37,31.11 39.37,24.77 38.1,23.5 RS08.39 | C35L.1 15.24,23.5 15.24,24.77 C35L.3 15.24,26.04 15.24,27.3 C35L.5 15.24,28.57 15.24,29.84 C35L.7 15.24,31.11 15.24,32.38 C35L.9 15.24,33.66 15.24,34.92 C35L.11 15.24,36.2 15.24,37.47 C35L.13 15.24,38.73 15.24,40.01 C35L.15 15.24,41.27 15.24,42.55 C35L.17 15.24,43.81 15.24,45.09 C35L.19 15.24,46.35 15.24,47.62 C35L.21 15.24,48.9 15.24,50.16 C35L.23 15.24,51.44 15.24,52.7 C35L.25 15.24,53.98 15.24,55.24 C35L.27 15.24,56.52 15.24,57.78 C35L.29 15.24,59.05 15.24,60.33 C35L.31 15.24,61.59 15.24,62.87 C35L.33 15.24,64.14 15.24,65.41 C35L.35 15.24,66.67 15.24,67.94 C35L.37 15.24,69.22 15.24,70.48 C35L.39 15.24,71.75 15.24,80.64 12.7,83.19 SV2.26 12.7,84.45 12.7,85.72 SV2.25 13.34,86.36 13.34,93.34 11.43,95.25 11.43,95.89 10.16,97.16 C20.2 10.16,98.42 13.97,102.23 13.97,111.12 15.24,112.39 C13.2 | 150.5,62.23 150.5,75.56 DAR8-11.8 149.22,76.83 147.96,78.11 147.96,84.45 | 150.5,62.23 C42.2 150.5,62.23 | 147.96,84.45 149.22,85.72 DAR8-11.4 | 147.96,84.45 147.96,96.52 150.5,96.52 C27.2 151.13,97.16 152.4,98.42 152.4,109.86 154.94,112.39 C18.2 | IC31.10 165.1,41.27 165.1,34.92 166.37,33.66 C38.2 | C40.2 151.13,26.04 151.13,40.64 150.5,41.27 DAR4-7.8 149.22,42.55 147.96,43.81 147.96,50.16 | 147.96,50.16 149.22,51.44 DAR4-7.4 | 150.5,62.23 147.96,62.23 147.96,50.16
  Top 0.254: D35L.39 86.36,70.48 86.36,69.22 D35L.37 86.36,67.94 86.36,66.67 D35L.35 86.36,65.41 86.36,64.14 D35L.33 86.36,62.87 86.36,61.59 D35L.31 86.36,60.33 86.36,59.05 D35L.29 86.36,57.78 86.36,56.52 D35L.27 86.36,55.24 86.36,53.98 D35L.25 86.36,52.7 86.36,51.44 D35L.23 86.36,50.16 86.36,48.9 D35L.21 86.36,47.62 86.36,46.35 D35L.19 86.36,45.09 86.36,43.81 D35L.17 86.36,42.55 86.36,41.27 D35L.15 86.36,40.01 86.36,38.73 D35L.13 86.36,37.47 86.36,36.2 D35L.11 86.36,34.92 86.36,33.66 D35L.9 86.36,32.38 86.36,31.11 D35L.7 86.36,29.84 86.36,28.57 D35L.5 86.36,27.3 86.36,26.04 D35L.3 86.36,24.77 86.36,23.5 D35L.1 | IC28.10 66.04,50.16 66.04,45.09 67.31,43.81 C35.2 67.31,42.55 67.94,41.91 67.94,32.38 67.31,31.75 71.75,27.3 | 71.75,26.04 71.75,24.77 73.03,23.5 IC35.13 | 71.75,26.04 73.03,27.3 IC35.15 | 71.75,27.3 71.75,26.04 | 71.75,27.3 71.75,31.11 73.03,32.38 IC35.17 | IC35.10 66.67,17.14 73.03,10.79 73.03,9.53 74.3,8.26 75.56,8.26 75.56,8.89 C41.2 | C39.2 135.89,62.87 135.89,74.93 135.25,75.56 DMA8-11.8 133.99,76.83 132.72,78.11 132.72,84.45 133.99,85.72 DMA8-11.4 | D36L.39 127,70.48 127,69.22 D36L.37 127,67.94 127,66.67 D36L.35 127,65.41 127,64.14 D36L.33 127,62.87 127,61.59 D36L.31 127,60.33 127,59.05 D36L.29 127,57.78 127,56.52 D36L.27 127,55.24 127,53.98 D36L.25 127,52.7 127,51.44 D36L.23 127,50.16 127,48.9 D36L.21 127,47.62 127,46.35 D36L.19 127,45.09 127,43.81 D36L.17 127,42.55 127,41.27 D36L.15 127,40.01 127,38.73 D36L.13 127,37.47 127,36.2 D36L.11 127,34.92 127,33.66 D36L.9 127,32.38 127,31.11 D36L.7 127,29.84 127,28.57 D36L.5 127,27.3 127,26.04 D36L.3 127,24.77 127,23.5 D36L.1
  Top 0.254: DMA0-3.4 133.35,17.78 131.44,17.78 131.44,22.23 133.35,24.13 136.53,24.13 136.53,27.94 C46.2 | C23.2 104.14,9.53 102.87,10.79 102.87,20.32 104.14,21.59 IC36.4 104.14,24.13 105.41,25.4 105.41,40.64 106.68,41.91 IC32.5 | J14.2 193.04,23.5 193.04,24.77 J13.2 193.04,26.04 193.04,27.3 J12.2 193.04,28.57 193.04,29.84 J11.2 193.04,31.11 193.04,32.38 J10.2 193.04,33.66 193.04,34.92 J9.2 193.04,36.2 193.04,37.47 J8.2 | D34L.1 185.42,23.5 185.42,24.77 D34L.3 185.42,26.04 185.42,27.3 D34L.5 185.42,28.57 185.42,29.84 D34L.7 185.42,31.11 185.42,32.38 D34L.9 185.42,33.66 185.42,34.92 D34L.11 185.42,36.2 185.42,37.47 D34L.13 185.42,38.73 185.42,40.01 D34L.15 185.42,41.27 185.42,42.55 D34L.17 185.42,43.81 185.42,45.09 D34L.19 185.42,46.35 185.42,47.62 D34L.21 185.42,48.9 185.42,50.16 D34L.23 185.42,51.44 185.42,52.7 D34L.25 185.42,53.98 185.42,55.24 D34L.27 185.42,56.52 185.42,57.78 D34L.29 185.42,59.05 185.42,60.33 D34L.31 185.42,61.59 185.42,62.87 D34L.33 185.42,64.14 185.42,65.41 D34L.35 185.42,66.67 185.42,67.94 D34L.37 185.42,69.22 185.42,70.48 D34L.39 | INTENB.4 196.22,9.53 197.49,9.53 INTENB.5 | 170.81,7.62 171.45,7.62 IC38.11 | 170.81,7.62 166.37,7.62 IC38.10 | 170.81,10.79 172.09,12.06 IC38.13 | 170.81,10.79 170.81,7.62 | 170.81,15.88 172.09,17.14 IC38.15 | 170.81,10.79 170.81,15.88 | 170.81,15.88 170.81,20.95 172.09,22.23 IC38.17 | INTENB.8 205.74,11.43 205.74,16.51 INTENB.9 205.74,19.05 203.2,21.59 203.2,22.23 C36L.1 203.2,23.5 203.2,24.77 C36L.3 203.2,26.04 203.2,27.3 C36L.5 203.2,28.57 203.2,29.84 C36L.7 203.2,31.11 203.2,32.38 C36L.9 203.2,33.66 203.2,34.92 C36L.11 203.2,36.2 203.2,37.47 C36L.13 203.2,38.73 203.2,40.01 C36L.15 203.2,41.27 203.2,42.55 C36L.17 203.2,43.81 203.2,45.09 C36L.19 203.2,46.35 203.2,47.62 C36L.21 203.2,48.9 203.2,50.16 C36L.23 203.2,51.44 203.2,52.7 C36L.25 203.2,53.98 203.2,55.24 C36L.27 203.2,56.52 203.2,57.78 C36L.29 203.2,59.05 203.2,60.33 C36L.31 203.2,61.59 203.2,62.87 C36L.33 203.2,64.14 203.2,65.41 C36L.35 203.2,66.67 203.2,67.94 C36L.37 203.2,69.22 203.2,70.48 C36L.39
  Top 0.254: IC37.10 210.19,8.26 208.91,9.53 208.91,15.88 210.19,17.14 IC37.6 | FIELD.8 211.46,70.48 211.46,64.77 212.09,64.14 C30.2 212.72,63.5 212.72,76.83 211.46,78.11 FIELD.5 210.19,79.38 210.19,80.64 FIELD.4 211.46,81.92 212.72,83.19 212.72,91.44 C44.2 212.09,92.08 212.09,95.25 211.46,95.89 IC12.7 211.46,97.16 212.72,98.42 212.72,114.3 C12.2 | C44X.2 212.09,133.99 211.46,133.35 211.46,132.72 IC8.1 | C31.2 166.37,67.94 165.74,68.58 165.74,75.56 IC24.10 165.74,76.83 167,78.11 167,99.69 166.37,100.33 166.37,100.97 C24.2 167,101.6 172.72,107.31 172.72,110.49 IC18.7 | IC7.8 200.66,123.19 199.39,121.92 199.39,114.3 200.66,113.03 IC11.7 | 132.08,121.92 132.08,120.65 IC17.15 132.08,118.11 129.54,115.57 129.54,113.03 IC17.1 | 132.08,121.92 132.08,123.19 IC9.2 132.08,125.73 134.62,128.27 134.62,130.81 IC9.12 | IC1.7 28.57,136.53 29.84,136.53 IC1.8 | C45.- 183.51,138.43 183.51,135.25 185.42,133.35 IC7.15 185.42,130.81 185.42,128.27 182.88,125.73 IC7.1 | IC10.12 162.56,130.81 162.56,128.27 160.02,125.73 IC10.2 | IC4.7 112.39,136.53 113.67,136.53 IC4.8 | IC5.7 144.78,135.89 144.78,134.62 143.51,133.35 143.51,127 144.78,125.73 IC9.7 144.15,123.83 144.15,121.92 132.08,121.92 | 312.42,25.4 312.42,43.81 G1.- 311.79,45.09 311.79,51.44 292.1,51.44 287.65,55.88 RF08A.39 | 312.42,25.4 312.42,14.61 G2.- | RF08A.31 277.5,55.88 277.5,48.26 278.13,47.62 278.13,46.99 278.13,44.45 277.5,43.81 277.5,41.91 276.23,40.64 276.23,31.11 IC42.16 276.86,29.21 275.59,27.94 275.59,8.89 276.86,7.62 IC43.16 | 312.42,25.4 297.81,25.4 IC44.7 | G3.- 313.06,109.86 314.32,109.86 G3.-@1
  Top 0.254: G4.- 313.06,79.38 314.32,79.38 G4.-@1 | RF08B.31 276.86,121.28 278.13,120.02 278.13,110.49 276.86,109.22 276.86,97.79 IC39.16 | IC48.7 71.12,166.37 72.39,167.64 72.39,177.8 71.12,179.07 IC47.7 | IC50.7 139.7,166.37 140.97,167.64 140.97,179.07 139.7,180.34 IC49.7 | IC52.7 208.28,166.37 207.01,167.64 207.01,168.28 207.01,175.9 208.28,177.16 208.28,179.07 IC51.7 | SV4.26 287.65,193.04 288.93,193.04 SV4.25 289.56,192.41 291.46,190.5 291.46,161.29 289.56,159.38 276.86,159.38 276.86,163.83 IC54.7 276.86,166.37 278.13,167.64 278.13,177.8 276.86,179.07 IC53.7
  Bottom 0.254: IC14.1 46.35,111.12 47.62,111.12 IC14.2 48.9,111.12 50.16,109.86 51.44,109.86 | 51.44,109.86 52.7,111.12 IC14.4 | 51.44,109.86 59.05,109.86 60.33,111.12 IC14.7 | C13.2 15.88,113.03 16.51,112.39 17.14,112.39 IC13.1 | IC20.10 36.2,97.16 36.83,97.79 42.55,97.79 C33.2 43.18,98.42 61.59,98.42 62.87,97.16 IC33.8 64.14,97.16 64.77,97.79 70.48,97.79 C21.2 71.75,97.79 72.39,97.79 73.03,98.42 89.53,98.42 90.81,97.16 IC21.8 92.08,97.16 92.71,97.79 98.42,97.79 C22.2 99.06,98.42 114.94,98.42 116.2,97.16 IC22.7 117.47,96.52 135.25,96.52 C8.2 136.53,96.52 137.79,97.79 149.22,97.79 150.5,96.52 C27.2 | C14.2 42.55,113.03 34.29,113.03 33.66,112.39 IC13.7 32.38,111.12 31.11,109.86 22.23,109.86 20.95,111.12 IC13.2 | RS08.39 37.47,22.86 33.66,19.05 29.21,19.05 28.57,18.41 24.77,18.41 24.13,17.78 IC34.10 21.59,17.78 20.95,18.41 15.24,18.41 11.43,22.23 11.43,24.13 13.34,24.13 14.61,25.4 C35L.3 | C34.2 23.5,43.18 15.88,43.18 C35L.17 | C26.2 23.5,76.2 19.68,76.2 15.24,71.75 C35L.39 | IC26.10 21.59,50.8 15.88,50.8 C35L.23 | J2.2 10.79,50.8 12.06,52.07 13.34,52.07 14.61,53.34 C35L.25 | IC31.10 163.83,41.91 160.66,41.91 159.38,43.18 152.4,43.18 151.13,41.91 DAR4-7.8 148.59,41.91 147.32,43.18 132.08,43.18 | D35L.31 87,60.96 92.08,60.96 93.34,59.69 C29.2 93.98,60.33 104.78,60.33 106.05,59.05 IC29.5 107.31,57.78 108.58,56.52 112.39,56.52 113.67,57.78 IC29.8 | C28.2 67.94,76.2 69.85,78.11 78.74,78.11 85.72,71.12 D35L.39 87,71.12 89.53,71.12 93.34,74.93 C25.2 93.98,75.56 104.78,75.56 | 104.78,75.56 106.05,74.3 IC25.5 | 104.78,75.56 112.39,75.56 113.67,74.3 IC25.8
  Bottom 0.254: C36.2 93.34,24.13 92.08,25.4 87,25.4 D35L.3 | D35L.17 87,43.18 92.08,43.18 93.34,44.45 C32.2 93.98,45.09 104.78,45.09 | 104.78,45.09 106.05,43.81 IC32.5 | 104.78,45.09 112.39,45.09 113.67,43.81 IC32.8 | IC35.17 74.93,33.02 76.2,31.75 84.45,31.75 85.72,30.48 D35L.7 | IC40.7 148.59,7.62 147.32,8.89 137.16,8.89 135.89,7.62 DMA0-3.8 133.35,7.62 122.56,7.62 IC23.7 121.28,6.99 120.02,5.71 111.12,5.71 109.86,6.99 IC23.2 108.58,8.26 107.31,9.53 104.14,9.53 C23.2 103.5,8.89 97.79,8.89 97.16,8.26 IC41.8 95.89,8.26 94.61,9.53 76.2,9.53 C41.2 | C39.2 135.25,62.23 133.99,63.5 127.64,63.5 D36L.33 | 132.08,43.18 133.35,41.91 DMA4-7.8 | 132.08,43.18 127.64,43.18 D36L.17 | DMA4-7.4 133.35,52.07 129.54,48.26 127.64,48.26 D36L.21 | IC36.4 104.78,22.23 106.05,22.23 IC36.5 107.31,23.5 108.58,24.77 112.39,24.77 113.67,23.5 IC36.8 114.94,22.23 115.57,21.59 125.09,21.59 126.36,22.86 D36L.1 | C46.2 135.25,27.94 127.64,27.94 D36L.5 | J6.2 192.41,43.18 186.06,43.18 D34L.17 | J8.2 192.41,38.1 186.06,38.1 D34L.13 | IC38.13 173.35,12.06 184.15,12.06 184.78,11.43 C43.2 185.42,12.06 193.68,12.06 194.94,10.79 INTENB.4 | IC19.7 201.29,89.53 203.2,91.44 211.46,91.44 C44.2 | C19.2 191.13,99.06 191.77,98.42 207.65,98.42 209.55,96.52 IC12.7 | INTENB.9 206.38,17.78 209.55,17.78 IC37.6 | C37.2 211.46,33.02 203.84,33.02 C36L.9 202.56,33.02 201.29,31.75 194.94,31.75 193.68,33.02 J10.2 | IC30.10 209.55,38.1 203.84,38.1 C36L.13 | FIELD.9 217.17,71.12 212.09,71.12 FIELD.8 209.55,71.12 203.84,71.12 C36L.39 | IC30.6 209.55,48.26 203.84,48.26 C36L.21 | INTENB.5 198.75,10.79 200.03,12.06 203.84,12.06 205.1,10.79 INTENB.8
  Bottom 0.254: IC7.8 201.29,125.09 208.28,132.08 209.55,132.08 IC8.1 | C12.2 211.46,114.3 203.2,114.3 201.29,112.39 IC11.7 200.03,112.39 198.75,113.67 182.88,113.67 C11.2 182.25,113.03 181.61,112.39 173.35,112.39 IC18.7 172.09,112.39 170.81,113.67 154.94,113.67 C18.2 154.31,113.03 148.59,113.03 147.96,112.39 IC17.8 146.69,112.39 145.41,113.67 127,113.67 C17.2 | IC16.15 102.23,118.75 104.14,116.84 129.54,116.84 131.44,118.75 IC17.15 | C9.2 127.64,125.73 128.27,126.36 130.18,126.36 131.44,125.09 IC9.2 | C15.2 71.12,113.67 79.38,113.67 80.64,112.39 IC15.4 81.92,112.39 83.19,113.67 87,113.67 88.27,112.39 IC15.7 89.53,112.39 90.17,113.03 95.89,113.03 C16.2 97.16,113.03 97.79,113.03 98.42,112.39 IC16.1 99.69,111.12 100.97,109.86 114.94,109.86 116.2,111.12 IC16.8 117.47,112.39 118.11,113.03 126.36,113.03 C17.2 | IC17.1 128.91,112.39 128.27,113.03 127.64,113.03 C17.2 | C1.2 10.79,138.43 11.43,139.06 26.04,139.06 27.3,137.79 IC1.7 | IC1.8 31.11,137.79 36.83,137.79 37.47,138.43 C2.2 38.1,139.06 53.98,139.06 55.24,137.79 IC2.7 56.52,136.53 57.78,136.53 IC2.8 59.05,137.79 64.77,137.79 65.41,138.43 C3.2 66.04,139.06 81.92,139.06 83.19,137.79 IC3.7 84.45,136.53 85.72,136.53 IC3.8 87,137.79 92.71,137.79 93.34,138.43 C4.2 94.61,138.43 95.25,139.06 109.86,139.06 111.12,137.79 IC4.7 | IC7.1 182.25,125.09 181.61,125.73 180.97,125.73 C7.2 179.71,125.73 173.99,125.73 173.35,125.09 IC10.7 172.09,125.09 170.81,126.36 158.12,126.36 | IC6.8 175.9,137.79 177.16,139.06 181.61,139.06 C45.- | IC9.7 145.41,125.09 146.05,125.73 154.31,125.73 C10.2 154.94,126.36 158.12,126.36