# EAGLE board spe10 (EAGLE 4.11), part 3 of 3
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
GND  (3 unrouted) (continued)
  Bottom 0.254: 158.12,126.36 159.38,125.09 IC10.2 | C6.2 154.94,137.79 145.41,137.79 IC5.7 144.15,137.79 142.88,139.06 127,139.06 C5.2 126.36,138.43 125.73,137.79 114.94,137.79 IC4.8 | G2.- 313.06,13.97 314.32,13.97 G2.-@1 | G1.- 313.06,44.45 314.32,44.45 G1.-@1 | RF08A.31 277.5,55.88 278.76,54.61 285.12,54.61 286.38,55.88 RF08A.39 | RF08B.31 277.5,121.92 278.76,123.19 285.12,123.19 286.38,121.92 RF08B.39 | IC45.16 277.5,71.75 296.55,90.81 IC46.7 | 295.27,93.34 296.55,92.08 IC46.7 | 295.27,93.34 294.64,93.98 279.4,93.98 277.5,95.89 IC39.16 | G4.- 311.79,80.64 301.62,90.81 297.81,90.81 IC46.7 | 295.27,93.34 311.79,109.86 G3.- | IC48.7 71.75,164.47 73.03,163.19 137.79,163.19 139.06,164.47 IC50.7 140.34,165.74 140.97,166.37 186.69,166.37 187.32,165.74 191.13,165.74 192.41,167 198.12,167 206.38,167 207.65,165.74 IC52.7 208.91,165.1 215.26,165.1 217.17,163.19 274.95,163.19 276.23,164.47 IC54.7
INT_RQ\  (via drill 0.61)
  Top 0.254: IC40.3 149.22,17.14 147.96,15.88 147.96,12.06 149.22,10.79 IC40.6 | v154.31,58.42 154.94,57.78 154.94,50.16 155.57,49.53 155.57,33.02 154.31,31.75 154.31,10.79 156.84,8.26 IC40.8
  Bottom 0.254: IC40.6 151.13,10.16 153.67,7.62 156.21,7.62 IC40.8 | v154.31,58.42 158.75,58.42 160.02,59.69 160.66,59.69 161.93,58.42 182.25,58.42 D34L.30
IOS\  (via drill 0.61)
  Top 0.254: v119.38,97.79 119.38,98.42 115.57,98.42 112.39,101.6 112.39,102.23 111.76,102.87 IC22.10 | v139.06,99.69 142.88,103.5 v142.88,106.05 | v153.67,107.31 154.94,106.05 v154.94,95.25 | v182.25,90.17 182.25,87.63 181.61,87 181.61,57.78 182.88,56.52 D34L.28
  Bottom 0.254: v119.38,97.79 135.25,97.79 137.16,99.69 v139.06,99.69 | v142.88,106.05 144.15,107.31 v153.67,107.31 | v154.94,95.25 177.16,95.25 v182.25,90.17
MEMSUPPLY  (via drill 0.61)  (1 unrouted)
  Top 0.508: v236.22,21.59 236.22,24.77 R3.2 236.22,26.04 236.22,44.45 D1.C | D3.C 278.76,13.34 278.76,42.55 D2.C | D6.C 236.22,110.49 236.22,89.53 R4.2 | D7.C 278.76,79.38 278.76,108.58 D5.C
  Bottom 0.508: D1.C 236.85,45.72 238.12,45.72 IC42.32 238.76,44.45 240.03,43.18 278.13,43.18 D2.C 280.04,42.55 281.94,42.55 281.94,34.29 IC44.14 | v236.22,21.59 238.12,21.59 IC43.32 | D6.C 236.85,111.12 238.12,111.12 IC39.32 239.4,111.12 241.3,109.22 278.13,109.22 D5.C 280.04,108.58 281.94,108.58 281.94,100.33 IC46.14 | R4.2 236.22,88.27 237.49,87 238.12,87 IC45.32
MYDEV\  (via drill 0.61)
  Top 0.254: 102.87,55.88 102.87,45.72 104.14,44.45 IC32.4 104.14,41.91 v104.14,38.1 | 102.87,55.88 104.14,57.15 IC29.4 | 102.87,55.88 102.87,71.12 104.14,72.39 IC25.4
  Bottom 0.254: v104.14,38.1 111.12,38.1 113.67,35.56 PAD1.1
N$1
  Top 0.254: IC36.9 114.3,31.75 114.3,32.38 PAD8.1
N$2  (via drill 0.61)
  Top 0.254: v194.31,130.18 194.31,121.92 193.04,120.65 IC11.11
  Bottom 0.254: v194.31,130.18 184.78,130.18 184.15,130.81 182.88,129.54 175.26,129.54 173.35,131.44 IC10.8
N$3  (via drill 0.61)
  Top 0.254: v145.41,49.53 144.78,48.9 144.78,11.43 140.97,11.43 140.34,12.06 140.34,15.24 135.89,15.24 DMA0-3.5
  Bottom 0.254: v145.41,49.53 143.51,49.53 DMA4-7.12
N$4  (via drill 0.61)
  Top 0.254: SW1.1 13.34,123.83 14.61,123.83 SW1.2 | SW1.3 18.41,123.83 19.68,123.83 SW1.4 20.95,123.83 22.23,123.83 SW1.5 23.5,123.83 24.77,123.83 SW1.6 26.04,123.83 27.3,123.83 SW1.7 | v53.34,93.34 53.34,95.25 IC33.4 | v40.64,93.98 37.47,97.16 v37.47,123.19
  Bottom 0.254: SW1.3 17.14,123.83 15.88,123.83 SW1.2 | SW1.7 28.57,123.83 29.84,123.83 SW1.8 31.11,123.83 36.83,123.83 v37.47,123.19 | v53.34,93.34 52.7,93.98 v40.64,93.98
N$5
  Top 0.254: IC36.15 99.06,31.75 99.06,32.38 PAD2.1
N$6
  Top 0.254: IC36.14 101.6,31.75 101.6,32.38 PAD3.1
N$7
  Top 0.254: IC36.13 104.14,31.75 104.14,32.38 PAD4.1
N$8
  Top 0.254: IC36.12 106.68,31.75 106.68,32.38 PAD5.1
N$9
  Top 0.254: IC36.11 109.22,31.75 109.22,32.38 PAD6.1
N$10
  Top 0.254: IC36.10 111.76,31.75 111.76,32.38 PAD7.1
N$11
  Top 0.254: IC36.7 111.76,24.13 116.84,29.21 116.84,32.38 PAD9.1
N$12
  Top 0.254: DAR4-7.14 156.84,55.24 155.57,56.52 155.57,60.33 156.21,60.96 157.48,60.96 157.48,73.66 155.57,75.56 155.57,87 156.84,88.27 DAR8-11.14 158.12,89.53 159.38,90.81 159.38,97.79 161.29,99.69 161.29,113.67 167,113.67 172.09,118.75 IC18.8
N$13  (via drill 0.61)
  Top 0.254: v145.41,50.8 144.78,51.44 144.78,81.28 142.88,83.19 DMA8-11.12
  Bottom 0.254: v145.41,50.8 137.16,50.8 135.89,49.53 DMA4-7.5
N$14  (via drill 0.61)
  Top 0.254: IC13.8 33.02,120.65 34.29,121.92 34.29,141.6 42.55,149.86 54.61,149.86 54.61,143.51 60.96,137.16 60.96,120.65 IC14.8 | v87.63,117.47 87.63,114.3 86.36,113.03 IC15.6
  Bottom 0.254: v87.63,117.47 87.63,121.28 62.87,121.28 61.59,120.02 IC14.8
N$15  (via drill 0.61)
  Top 0.254: v49.53,147.96 49.53,139.7 50.8,138.43 IC2.5 | v125.09,149.22 128.27,146.05 128.27,142.24 132.08,138.43 IC5.2
  Bottom 0.254: v49.53,147.96 51.44,149.86 124.46,149.86 v125.09,149.22
N$16  (via drill 0.61)
  Top 0.254: v146.69,15.24 147.32,15.88 v147.32,72.39 | v151.76,74.93 151.76,81.92 150.5,83.19 DAR8-11.5
  Bottom 0.254: v146.69,15.24 143.51,15.24 DMA0-3.12 | v147.32,72.39 149.86,74.93 v151.76,74.93
N$17
  Top 0.254: SW2.1 41.27,123.83 42.55,123.83 SW2.2 43.81,123.83 45.09,123.83 SW2.3 46.35,123.83 47.62,123.83 SW2.4 48.9,123.83 50.16,123.83 SW2.5 51.44,123.83 52.7,123.83 SW2.6 | IC33.5 55.88,97.79 54.61,99.06 54.61,121.92 53.34,123.19 SW2.6 | SW2.6 53.98,123.83 55.24,123.83 SW2.7 56.52,123.83 57.78,123.83 SW2.8
N$18
  Top 0.254: IC44.6 294,24.77 292.74,24.77 IC44.5
  Bottom 0.254: IC44.5 292.1,24.13 291.46,23.5 287.65,23.5 287.02,24.13 IC44.3
N$19  (via drill 0.61)
  Top 0.254: v58.42,99.69 58.42,97.79 IC33.6 | v67.31,99.06 67.94,99.69 67.94,123.83 SW3.1 | SW3.2 71.75,123.83 73.03,123.83 SW3.3 74.3,123.83 75.56,123.83 SW3.4 76.83,123.83 78.11,123.83 SW3.5 79.38,123.83 80.64,123.83 SW3.6 81.92,123.83 83.19,123.83 SW3.7 84.45,123.83 85.72,123.83 SW3.8
  Bottom 0.254: v58.42,99.69 59.05,99.06 v67.31,99.06 | SW3.2 70.48,123.83 69.22,123.83 SW3.1
N$20  (via drill 0.61)
  Top 0.254: v60.96,100.33 60.96,97.79 IC33.7 | v92.71,100.97 v92.71,123.19 | SW4.1 97.16,123.83 98.42,123.83 SW4.2 99.69,123.83 100.97,123.83 SW4.3 102.23,123.83 103.5,123.83 SW4.4 104.78,123.83 106.05,123.83 SW4.5 | SW4.6 109.86,123.83 111.12,123.83 SW4.7 112.39,123.83 113.67,123.83 SW4.8
  Bottom 0.254: v60.96,100.33 72.39,100.33 73.03,99.69 88.9,99.69 90.17,100.97 v92.71,100.97 | v92.71,123.19 93.34,123.83 95.89,123.83 SW4.1 | SW4.6 108.58,123.83 107.31,123.83 SW4.5
N$21  (via drill 0.61)
  Top 0.254: v77.47,147.96 77.47,143.51 78.11,142.88 78.11,139.06 78.74,138.43 IC3.5 | v127.64,147.96 135.89,147.96 135.89,139.7 137.16,138.43 IC5.4
  Bottom 0.254: v77.47,147.96 98.42,147.96 99.69,149.22 123.83,149.22 125.09,147.96 v127.64,147.96
N$22  (via drill 0.61)
  Top 0.254: 140.34,52.7 140.34,41.27 142.24,39.37 142.24,26.67 140.97,26.67 140.34,26.04 140.34,22.23 141.6,20.95 DMA0-3.14 | 140.34,52.7 141.6,53.98 DMA4-7.14 | 140.34,52.7 140.34,60.96 141.6,60.96 142.24,61.59 142.24,73.03 140.34,74.93 140.34,87 141.6,88.27 DMA8-11.14 142.88,89.53 144.15,90.81 v144.15,106.05 | v170.18,106.05 170.18,110.49 IC18.6
  Bottom 0.254: v170.18,106.05 v144.15,106.05
N$23
  Bottom 0.254: IC1.5 23.5,136.53 24.77,135.25 115.57,135.25 116.84,136.53 128.91,136.53 IC5.1
N$24
  Top 0.254: IC4.5 106.68,138.43 106.05,139.06 106.05,142.88 105.41,143.51 105.41,146.05 109.86,150.5 138.43,150.5 138.43,139.7 139.7,138.43 IC5.5
N$25  (via drill 0.61)
  Top 0.254: v154.31,49.53 153.67,50.16 153.67,57.78 153.03,58.42 153.03,75.56 152.4,76.2 v152.4,83.82
  Bottom 0.254: v154.31,49.53 151.13,49.53 DAR4-7.5 | v152.4,83.82 156.21,83.82 DAR8-11.12
N$26
  Top 0.254: IC22.1 101.6,97.79 102.87,99.06 102.87,113.03 107.31,117.47 111.12,117.47 111.12,118.75 IC16.11
N$27  (via drill 0.61)
  Top 0.254: v133.35,106.05 137.16,109.86 137.16,110.49 IC17.4
  Bottom 0.254: v133.35,106.05 111.12,106.05 109.86,104.78 IC22.11
N$28  (via drill 0.61)
  Top 0.254: v184.15,121.28 184.15,91.44 185.42,90.17 IC19.1
  Bottom 0.254: v184.15,121.28 185.42,122.56 191.13,122.56 192.41,123.83 IC7.5
N$29
  Top 0.254: RA.2 220.98,120.02 220.98,121.28 RB.1 220.98,122.56 222.25,123.83 222.25,125.73 219.07,128.91 IC8.7
N$30
  Top 0.254: IC12.2 210.19,109.86 210.19,111.12 IC12.1 210.82,112.39 210.82,117.47 212.72,119.38 212.72,125.09 211.46,126.36 IC8.3 209.55,127 208.28,128.27 208.28,128.91 RL.2
N$31
  Top 0.254: IC18.11 165.1,120.65 166.37,121.92 166.37,129.54 167.64,130.81 IC10.10
N$32
  Top 0.254: C44X.1 217.17,133.99 216.53,133.35 216.53,128.91 217.81,127.64 IC8.6
  Bottom 0.254: 215.26,125.73 216.53,127 217.17,127 IC8.6 | 215.26,125.73 211.46,121.92 RB.2 | 215.26,125.73 214.63,125.73 211.46,128.91 IC8.2
N$33
  Top 0.254: IC19.11 193.04,97.79 191.77,99.06 191.77,129.54 193.04,130.81 IC7.12
N$34
  Top 0.254: IC8.5 219.71,124.46 220.34,124.46 C43X.2
N$35
  Top 0.254: IC44.2 285.12,26.04 285.75,26.67 285.75,52.07 288.93,52.07 J1.2
  Bottom 0.254: IC44.2 283.85,24.77 282.57,24.77 IC44.1
N$36
  Top 0.254: D7.A 290.19,78.11 291.46,76.83 G4.+@1 | G4.+@2 294,75.56 292.74,75.56 G4.+@1 | G4.+@3 294,84.45 292.74,84.45 G4.+ 292.74,83.19 293.37,82.55 293.37,81.28 G4.+@4 293.37,78.74 293.37,77.47 292.74,76.83 G4.+@1
N$37
  Top 0.254: IC12.9 217.81,99.69 217.81,100.97 IC12.10 217.81,102.23 217.81,103.5 IC12.11
N$38
  Top 0.254: IC46.6 294,90.81 292.74,90.81 IC46.5
  Bottom 0.254: IC46.3 287.65,90.81 288.93,89.53 290.19,89.53 291.46,90.81 IC46.5
N$39
  Top 0.254: IC46.2 284.48,90.17 287.02,87.63 290.83,87.63 290.83,105.41 287.65,108.58 287.65,116.2 288.93,117.47 J15.2
  Bottom 0.254: IC46.1 282.57,90.81 283.85,90.81 IC46.2
N$40
  Bottom 0.254: IC12.5 212.09,101.6 217.17,96.52 IC12.8
N$41
  Top 0.254: D5.A 290.19,108.58 291.46,107.31 G3.+@1 | G3.+@2 294,106.05 292.74,106.05 G3.+@1 | G3.+@3 294,114.94 292.74,114.94 G3.+ 292.74,113.67 293.37,113.03 293.37,111.76 G3.+@4 293.37,109.22 293.37,107.95 292.74,107.31 G3.+@1
N$42
  Top 0.254: R5.1 10.16,183.51 12.7,186.06 12.7,187.32 F.3.A
N$43
  Top 0.254: R6.1 25.4,183.51 27.94,186.06 27.94,187.32 F.2.A
N$44
  Top 0.254: R7.1 40.64,183.51 43.18,186.06 43.18,187.32 F.1.A
N$45
  Top 0.254: R8.1 78.74,183.51 81.28,186.06 81.28,187.32 DEA8.A
N$46
  Top 0.254: R9.1 93.98,183.51 96.52,186.06 96.52,187.32 DEA7.A
N$47
  Top 0.254: R10.1 109.22,183.51 111.76,186.06 111.76,187.32 DEA6.A
N$48
  Top 0.254: R11.1 147.32,183.51 149.86,186.06 149.86,187.32 DEA5.A
N$49
  Top 0.254: R12.1 162.56,183.51 165.1,186.06 165.1,187.32 DEA4.A
N$50
  Top 0.254: R13.1 177.8,183.51 180.34,186.06 180.34,187.32 DEA3.A
N$51
  Top 0.254: R14.1 215.9,183.51 218.44,186.06 218.44,187.32 DEA2.A
N$52
  Top 0.254: R15.1 231.14,183.51 233.68,186.06 233.68,187.32 DEA1.A
N$53
  Top 0.254: SW1.16 13.34,131.44 14.61,130.18 19.05,130.18 19.05,133.99 20.32,135.25 20.32,135.89 IC1.4
N$54
  Top 0.254: SW1.15 15.24,133.35 17.78,135.89 IC1.3
N$55
  Bottom 0.254: SW1.14 17.78,133.35 15.24,135.89 IC1.2
N$56
  Bottom 0.254: IC1.1 13.34,136.53 16.51,133.35 16.51,130.18 18.41,130.18 19.68,131.44 SW1.13
N$57  (via drill 0.61)
  Top 0.254: v19.05,135.25 19.05,140.97 17.78,142.24 17.78,143.51 IC1.14
  Bottom 0.254: v19.05,135.25 22.23,135.25 24.77,132.72 SW1.11
N$58
  Top 0.254: SW1.10 27.3,132.72 24.13,135.89 24.13,139.7 20.32,143.51 IC1.13
N$59
  Top 0.254: SW1.9 29.84,132.72 26.67,135.89 26.67,139.7 22.86,143.51 IC1.12
N$60
  Top 0.254: SW1.12 22.86,133.35 21.59,134.62 21.59,139.7 19.05,142.24 19.05,146.05 18.41,146.69 15.24,146.69 15.24,146.05 IC1.15
N$61
  Top 0.254: SW2.16 40.64,133.35 41.91,134.62 41.91,138.43 42.55,139.06 47.62,139.06 47.62,137.79 IC2.4
N$62
  Top 0.254: SW2.15 43.18,133.35 45.72,135.89 IC2.3
N$63
  Top 0.254: SW2.14 45.09,131.44 43.81,130.18 41.91,130.18 41.91,133.35 43.18,134.62 43.18,135.89 IC2.2
N$64
  Top 0.254: IC2.1 40.64,135.89 39.37,134.62 39.37,130.81 40.64,129.54 47.62,129.54 47.62,131.44 SW2.13
N$65
  Top 0.254: SW2.11 52.7,132.72 49.53,135.89 49.53,138.43 45.72,142.24 45.72,143.51 IC2.14
N$66
  Top 0.254: SW2.10 56.52,131.44 57.78,130.18 59.69,130.18 59.69,133.35 57.15,135.89 57.15,138.43 52.07,143.51 52.07,146.69 49.53,149.22 48.26,149.22 48.26,146.05 IC2.13
N$67
  Top 0.254: SW2.9 57.78,132.72 54.61,135.89 54.61,139.7 50.8,143.51 IC2.12
N$68
  Top 0.254: SW3.16 69.22,131.44 70.48,130.18 74.93,130.18 74.93,133.35 76.2,134.62 76.2,135.89 IC3.4
N$69
  Top 0.254: SW3.15 71.12,133.35 73.66,135.89 IC3.3
N$70
  Top 0.254: SW3.14 73.66,133.35 74.93,134.62 74.93,138.43 74.3,139.06 71.12,139.06 71.12,138.43 IC3.2
N$71
  Top 0.254: IC3.1 68.58,135.89 67.31,134.62 67.31,130.81 68.58,129.54 75.56,129.54 75.56,131.44 SW3.13
N$72
  Top 0.254: SW3.11 81.28,133.35 82.55,134.62 82.55,146.05 78.74,149.86 69.85,149.86 69.85,143.51 70.48,142.88 73.03,142.88 73.03,144.15 IC3.14
N$73
  Top 0.254: SW3.10 83.19,131.44 81.92,130.18 77.47,130.18 77.47,142.24 76.2,143.51 IC3.13
N$74  (via drill 0.61)
  Top 0.254: v87.63,142.24 87.63,134.62 86.36,133.35 SW3.9
  Bottom 0.254: v87.63,142.24 87,142.88 80.64,142.88 79.38,144.15 IC3.12
N$75
  Top 0.254: SW4.16 97.16,131.44 98.42,130.18 102.87,130.18 102.87,133.35 104.14,134.62 104.14,135.89 IC4.4
N$76
  Top 0.254: SW4.15 99.06,133.35 101.6,135.89 IC4.3
N$77
  Top 0.254: SW4.14 101.6,133.35 102.87,134.62 102.87,138.43 102.23,139.06 99.06,139.06 99.06,138.43 IC4.2
N$78
  Top 0.254: IC4.1 96.52,135.89 95.25,134.62 95.25,130.81 96.52,129.54 103.5,129.54 103.5,131.44 SW4.13
N$79  (via drill 0.61)
  Top 0.254: v97.79,133.99 97.79,139.7 101.6,143.51 IC4.14
  Bottom 0.254: v97.79,133.99 107.31,133.99 108.58,132.72 SW4.11
N$80
  Top 0.254: SW4.10 111.12,132.72 108.58,135.25 105.41,135.25 105.41,142.24 104.14,143.51 IC4.13
N$81
  Top 0.254: SW4.9 113.67,132.72 110.49,135.89 110.49,139.7 106.68,143.51 IC4.12
N$82
  Top 0.254: SW4.12 106.68,130.81 103.5,127.64 94.61,127.64 94.61,137.16 95.25,137.79 95.25,139.7 99.06,143.51 IC4.15
N$83
  Top 0.254: SW3.12 78.74,133.35 80.01,134.62 80.01,146.69 77.47,149.22 71.12,149.22 71.12,146.05 IC3.15
N$84
  Top 0.254: SW2.12 50.8,130.81 47.62,127.64 38.73,127.64 38.73,137.16 39.37,137.79 39.37,139.7 43.18,143.51 IC2.15
N$85
  Top 0.254: R16.1 246.38,183.51 246.38,191.13 247.65,192.41 248.92,192.41 248.92,188.59 DEA0.A
N$86
  Bottom 0.254: R17.1 8.26,182.88 10.79,180.34 12.06,180.34 DMA00.A
N$87
  Bottom 0.254: R18.1 23.5,182.88 26.04,180.34 27.3,180.34 DMA01.A
N$88
  Bottom 0.254: R19.1 38.73,182.88 41.27,180.34 42.55,180.34 DMA02.A
N$89
  Bottom 0.254: R20.1 76.83,182.88 79.38,180.34 80.64,180.34 DMA03.A
N$90
  Bottom 0.254: R21.1 92.08,182.88 94.61,180.34 95.89,180.34 DMA04.A
N$91
  Bottom 0.254: R22.1 107.31,182.88 109.86,180.34 111.12,180.34 DMA05.A
N$92
  Bottom 0.254: R23.1 145.41,182.88 147.96,180.34 149.22,180.34 DMA06.A
N$93
  Bottom 0.254: R24.1 160.66,182.88 163.19,180.34 164.47,180.34 DMA07.A
N$94
  Bottom 0.254: R25.1 175.9,182.88 178.44,180.34 179.71,180.34 DMA08.A
N$95
  Bottom 0.254: R26.1 214,182.88 216.53,180.34 217.81,180.34 DMA09.A
N$96
  Top 0.254: R27.1 229.24,182.88 231.78,180.34 233.04,180.34 DMA10.A
N$97  (via drill 0.61)
  Top 0.254: v246.38,180.34 246.38,180.97 244.47,182.88 R28.1
  Bottom 0.254: v246.38,180.34 248.28,180.34 DMA11.A
N$98
  Bottom 0.254: R29.1 8.26,170.18 10.79,172.72 12.06,172.72 DMB00.A
N$99
  Bottom 0.254: R30.1 23.5,170.18 26.04,172.72 27.3,172.72 DMB01.A
N$100
  Bottom 0.254: R31.1 38.73,170.18 41.27,172.72 42.55,172.72 DMB02.A
N$101
  Bottom 0.254: R32.1 76.83,170.18 79.38,172.72 80.64,172.72 DMB03.A
N$102
  Bottom 0.254: R33.1 92.08,170.18 94.61,172.72 95.89,172.72 DMB04.A
N$103
  Bottom 0.254: R34.1 107.31,170.18 109.86,172.72 111.12,172.72 DMB05.A
N$104
  Bottom 0.254: R35.1 145.41,170.18 147.96,172.72 149.22,172.72 DMB06.A
N$105
  Bottom 0.254: R36.1 160.66,170.18 163.19,172.72 164.47,172.72 DMB07.A
N$106
  Bottom 0.254: R37.1 175.9,170.18 178.44,172.72 179.71,172.72 DMB08.A
N$107
  Bottom 0.254: R38.1 214,170.18 216.53,172.72 217.81,172.72 DMB09.A
N$108
  Bottom 0.254: R39.1 229.24,170.18 231.78,172.72 233.04,172.72 DMB10.A
N$109  (via drill 0.61)
  Top 0.254: v243.84,172.72 243.84,170.81 R40.1
  Bottom 0.254: v243.84,172.72 248.28,172.72 DMB11.A
N$110
  Top 0.254: CIE.A 12.7,165.74 10.16,168.28 10.16,169.54 R41.1
N$111
  Top 0.254: EIE.A 27.94,165.74 25.4,168.28 25.4,169.54 R42.1
N$112
  Top 0.254: PIE.A 43.18,165.74 40.64,168.28 40.64,169.54 R43.1
N$113
  Top 0.254: DRE.A 81.28,165.74 78.74,168.28 78.74,169.54 R44.1
N$114
  Top 0.254: R/W.A 96.52,165.74 93.98,168.28 93.98,169.54 R45.1
N$115
  Top 0.254: DBR.A 111.76,165.74 109.22,168.28 109.22,169.54 R46.1
N$116
  Top 0.254: DRL.A 149.86,165.74 147.32,168.28 147.32,169.54 R47.1
N$117
  Top 0.254: WLS.A 165.1,165.74 162.56,168.28 162.56,169.54 R48.1
N$118
  Top 0.254: NXD.A 180.34,165.74 177.8,168.28 177.8,169.54 R49.1
N$119
  Top 0.254: WCO.A 218.44,165.74 215.9,168.28 215.9,169.54 R50.1
N$120
  Top 0.254: PER.A 233.68,165.74 231.14,168.28 231.14,169.54 R51.1
N$121  (via drill 0.61)
  Top 0.254: v248.92,169.54 248.92,165.74 DCF.A
  Bottom 0.254: v248.92,169.54 248.28,170.18 247.01,170.18 R52.1
N$122
  Bottom 0.254: F.3.K 15.24,187.32 15.24,181.61 14.61,181.61 13.97,180.97 13.97,178.44 56.52,178.44 57.78,179.71 IC47.2
N$123  (via drill 0.61)
  Top 0.254: v34.29,184.78 31.11,187.96 F.2.K
  Bottom 0.254: v34.29,184.78 34.92,184.15 59.69,184.15 62.87,180.97 IC47.4
N$124
  Bottom 0.254: F.1.K 46.35,187.96 48.26,189.87 71.75,189.87 72.39,189.23 72.39,182.25 70.48,182.25 69.22,180.97 IC47.6
N$125
  Bottom 0.254: DMA00.K 15.88,180.34 21.59,186.06 69.22,186.06 70.48,187.32 IC47.8
N$126
  Top 0.254: DMA01.K 31.11,180.34 43.18,192.41 66.04,192.41 66.04,189.23 IC47.10
N$127
  Top 0.254: DMA02.K 45.72,180.97 55.24,190.5 57.15,190.5 57.15,186.69 57.78,186.06 60.33,186.06 60.33,187.32 IC47.12
N$128
  Bottom 0.254: IC48.2 57.78,165.74 56.52,167 34.29,167 31.11,163.83 24.77,163.83 15.88,172.72 DMB00.K
N$129
  Top 0.254: DMB01.K 31.11,172.72 41.27,162.56 69.85,162.56 69.85,166.37 69.22,167 63.5,167 63.5,166.37 IC48.4
N$130
  Top 0.254: G2.+@1 292.1,10.79 292.1,17.14 G2.+ 292.74,18.41 292.74,19.05 294,19.05 G2.+@3 294.64,18.41 294.64,15.24 G2.+@4 | G2.+@4 294.64,12.7 294.64,9.53 G2.+@2 | D3.A 290.83,12.7 293.37,12.7 G2.+@4
N$131
  Top 0.254: G1.+@1 292.1,41.27 292.1,47.62 G1.+ 292.74,48.9 292.74,49.53 294,49.53 G1.+@3 294.64,48.9 294.64,45.72 G1.+@4 | G1.+@4 294.64,43.18 294.64,40.01 G1.+@2 | D2.A 290.83,43.18 293.37,43.18 G1.+@4
N$132
  Top 0.254: DMB02.K 45.72,172.09 44.45,170.81 44.45,164.47 45.72,163.19 67.94,163.19 67.94,164.47 IC48.6
N$133
  Bottom 0.254: CIE.K 15.24,165.74 15.24,171.45 14.61,171.45 13.97,172.09 13.97,174.62 69.22,174.62 70.48,173.35 IC48.8
N$134
  Bottom 0.254: EIE.K 31.11,165.1 34.92,168.91 62.23,168.91 65.41,172.09 IC48.10
N$135
  Top 0.254: PIE.K 46.35,165.1 54.61,165.1 54.61,166.37 60.33,172.09 IC48.12
N$136
  Bottom 0.254: DEA7.K 99.69,187.96 103.5,184.15 129.54,184.15 131.44,182.25 IC49.4
N$137  (via drill 0.61)
  Top 0.254: v132.72,186.06 136.53,182.25 IC49.6
  Bottom 0.254: v132.72,186.06 116.84,186.06 114.94,187.96 DEA6.K
N$138  (via drill 0.61)
  Top 0.254: v136.53,184.78 139.7,187.96 IC49.8
  Bottom 0.254: v136.53,184.78 113.03,184.78 108.58,189.23 78.11,189.23 78.11,186.69 83.82,180.97 DMA03.K
N$139  (via drill 0.61)
  Top 0.254: v109.22,189.87 99.69,180.34 DMA04.K
  Bottom 0.254: v109.22,189.87 110.49,191.13 132.72,191.13 133.99,189.87 IC49.10
N$140
  Top 0.254: DMA05.K 114.3,180.97 123.19,189.87 123.19,190.5 128.27,195.58 129.54,195.58 129.54,190.5 IC49.12
N$141  (via drill 0.61)
  Top 0.254: v125.73,174.62 125.73,167.64 127,166.37 IC50.2
  Bottom 0.254: v125.73,174.62 86.36,174.62 84.45,172.72 DMB03.K
N$142  (via drill 0.61)
  Top 0.254: v105.41,161.93 105.41,165.74 99.06,172.09 DMB04.K | v132.08,161.93 132.08,163.83 IC50.4
  Bottom 0.254: v105.41,161.93 v132.08,161.93
N$143  (via drill 0.61)
  Top 0.254: v118.11,169.54 114.94,172.72 DMB05.K | v135.89,169.54 135.89,168.91 137.16,167.64 137.16,166.37 IC50.6
  Bottom 0.254: v118.11,169.54 v135.89,169.54
N$144  (via drill 0.61)
  Top 0.254: v100.33,169.54 100.33,167 99.06,165.74 R/W.K
  Bottom 0.254: v100.33,169.54 100.97,168.91 114.94,168.91 117.47,171.45 123.19,171.45 123.83,170.81 132.72,170.81 133.99,172.09 IC50.10
N$145  (via drill 0.61)
  Top 0.254: v129.54,168.28 129.54,171.45 IC50.12
  Bottom 0.254: v129.54,168.28 118.11,168.28 114.94,165.1 DBR.K
N$146  (via drill 0.61)
  Top 0.254: v156.84,184.15 153.03,187.96 DEA5.K
  Bottom 0.254: v156.84,184.15 180.34,184.15 182.88,181.61 191.77,181.61 192.41,182.25 193.68,182.25 194.94,180.97 IC51.2
N$147  (via drill 0.61)
  Top 0.254: v173.99,175.9 173.99,180.97 167.64,187.32 DEA4.K | v200.03,175.9 200.66,176.53 200.66,179.07 IC51.4
  Bottom 0.254: v173.99,175.9 174.62,176.53 198.75,176.53 199.39,175.9 v200.03,175.9
N$148  (via drill 0.61)
  Top 0.254: v203.2,184.15 205.74,181.61 IC51.6
  Bottom 0.254: v203.2,184.15 202.56,184.78 198.12,184.78 197.49,184.15 187.32,184.15 183.51,187.96 DEA3.K
N$149  (via drill 0.61)
  Top 0.254: v190.5,179.07 191.13,179.71 v191.13,186.06
  Bottom 0.254: v190.5,179.07 154.31,179.07 153.03,180.34 DMA06.K | v191.13,186.06 206.38,186.06 207.65,187.32 IC51.8
N$150  (via drill 0.61)
  Top 0.254: v172.09,194.31 166.37,188.59 166.37,182.25 167.64,180.97 DMA07.K | v199.39,194.94 199.39,186.69 200.03,186.06 202.56,186.06 202.56,187.32 IC51.10
  Bottom 0.254: v172.09,194.31 173.35,195.58 198.75,195.58 v199.39,194.94
N$151  (via drill 0.61)
  Top 0.254: v184.78,183.51 184.78,182.88 182.88,180.97 DMA08.K | v198.12,183.51 198.12,186.69 IC51.12
  Bottom 0.254: v184.78,183.51 v198.12,183.51
N$152  (via drill 0.61)
  Top 0.254: v158.12,177.8 153.03,172.72 DMB06.K | v194.31,178.44 194.31,167.64 195.58,166.37 IC52.2
  Bottom 0.254: v158.12,177.8 193.68,177.8 v194.31,178.44
N$153  (via drill 0.61)
  Top 0.254: v177.16,163.83 168.28,172.72 DMB07.K
  Bottom 0.254: v177.16,163.83 177.8,163.19 198.75,163.19 200.03,164.47 IC52.4
N$154  (via drill 0.61)
  Top 0.254: v205.74,169.54 205.74,166.37 IC52.6
  Bottom 0.254: v205.74,169.54 198.12,169.54 197.49,169.54 187.32,169.54 183.51,172.72 DMB08.K
N$155  (via drill 0.61)
  Top 0.254: v169.54,170.18 169.54,167.64 167.64,165.74 WLS.K
  Bottom 0.254: v169.54,170.18 175.26,175.9 198.12,175.9 199.39,174.62 201.29,174.62 202.56,173.35 IC52.10
N$156  (via drill 0.61)
  Top 0.254: v187.32,173.99 187.32,170.18 182.88,165.74 NXD.K
  Bottom 0.254: v187.32,173.99 188.59,175.26 196.85,175.26 198.12,173.99 IC52.12
N$157  (via drill 0.61)
  Top 0.254: v222.88,182.88 222.88,185.42 220.98,187.32 DEA2.K
  Bottom 0.254: v222.88,182.88 224.16,181.61 257.18,181.61 257.81,180.97 259.71,180.97 260.99,182.25 262.25,182.25 263.52,180.97 IC53.2
N$158  (via drill 0.61)
  Top 0.254: v262.89,186.06 264.8,184.15 264.8,182.25 265.43,181.61 265.43,179.07 266.06,178.44 268.61,178.44 268.61,179.71 IC53.4
  Bottom 0.254: v262.89,186.06 260.99,186.06 259.71,187.32 258.44,187.32 257.81,186.69 238.12,186.69 236.85,187.96 DEA1.K
N$159  (via drill 0.61)
  Top 0.254: v257.81,182.25 252.09,187.96 DEA0.K
  Bottom 0.254: v257.81,182.25 258.44,182.88 265.43,182.88 266.06,182.25 272.42,182.25 273.69,180.97 IC53.6
N$160
  Top 0.254: DMA09.K 221.62,180.34 235.59,194.31 276.86,194.31 276.86,189.23 IC53.8
N$161  (via drill 0.61)
  Top 0.254: v236.85,184.78 236.85,181.61 236.22,180.97 DMA10.K | v258.44,186.06 260.35,187.96 260.35,189.23 263.52,192.41 271.78,192.41 IC53.10
  Bottom 0.254: v236.85,184.78 238.12,186.06 v258.44,186.06
N$162  (via drill 0.61)
  Top 0.254: v255.27,183.51 252.09,180.34 DMA11.K | v266.06,183.51 266.7,184.15 266.7,186.69 IC53.12
  Bottom 0.254: v255.27,183.51 v266.06,183.51
N$163
  Top 0.254: DMB09.K 226.69,172.72 227.33,172.09 234.31,179.07 237.49,179.07 237.49,183.51 238.76,184.78 241.3,184.78 241.3,170.18 240.66,169.54 240.66,149.86 243.21,147.32 243.21,144.15 265.43,144.15 265.43,162.56 264.16,163.83 IC54.2
N$164  (via drill 0.61)
  Top 0.254: v258.44,172.09 259.08,171.45 v259.08,166.37
  Bottom 0.254: v258.44,172.09 257.81,171.45 238.12,171.45 236.85,172.72 DMB10.K | v259.08,166.37 259.71,167 267.33,167 268.61,165.74 IC54.4
N$165  (via drill 0.61)
  Top 0.254: v252.73,169.54 252.73,170.81 251.46,172.09 DMB11.K | v273.69,169.54 274.32,168.91 274.32,166.37 IC54.6
  Bottom 0.254: v252.73,169.54 v273.69,169.54
N$166  (via drill 0.61)
  Top 0.254: v241.94,146.69 240.03,148.59 240.03,170.18 240.66,170.81 240.66,184.15 239.4,184.15 238.12,182.88 238.12,178.44 234.95,178.44 221.62,165.1 WCO.K | v274.32,147.32 275.59,148.59 275.59,169.54 276.86,170.81 276.86,171.45 IC54.8
  Bottom 0.254: v241.94,146.69 242.57,147.32 v274.32,147.32
N$167
  Top 0.254: PER.K 236.22,164.47 236.22,148.59 241.3,143.51 273.05,143.51 273.05,168.91 271.78,170.18 271.78,171.45 IC54.10
N$168  (via drill 0.61)
  Top 0.254: v251.46,168.28 251.46,165.74 DCF.K
  Bottom 0.254: v251.46,168.28 273.69,168.28 274.95,169.54 274.95,170.18 274.32,170.18 273.69,170.81 268.61,170.81 267.33,172.09 IC54.12
N$169
  Top 0.254: DRE.K 83.82,164.47 83.82,160.66 PAD10.1
N$170
  Top 0.254: DRL.K 152.4,164.47 152.4,160.66 PAD11.1
N$171
  Bottom 0.254: DEA8.K 84.45,187.96 93.34,179.07 124.46,179.07 126.36,180.97 IC49.2
NXD  (via drill 0.61)  (1 unrouted)
  Top 0.254: v207.65,53.34 207.01,52.7 v207.01,6.99 | v118.75,4.45 116.84,6.35 IC23.5 | v190.5,161.29 190.5,170.81 v189.87,171.45 | v226.06,161.93 227.97,163.83 234.95,163.83 234.95,165.74 235.59,166.37 238.76,166.37 238.76,153.67 v238.12,153.03
  Bottom 0.254: IC23.5 114.3,10.16 74.93,10.16 74.3,10.79 53.98,10.79 52.07,8.89 34.92,8.89 33.66,7.62 SV1.17 | v207.01,6.99 205.74,5.71 153.67,5.71 153.03,6.35 137.16,6.35 135.89,5.08 119.38,5.08 v118.75,4.45 | v207.65,53.34 IC30.4 | v189.87,171.45 190.5,170.81 193.68,170.81 IC52.13 | v190.5,161.29 191.13,161.93 209.55,161.93 210.19,161.29 211.46,161.29 212.09,161.93 v226.06,161.93 | v238.12,153.03 240.66,150.5 241.94,149.22 262.25,149.22 263.52,151.13 SV3.17
NXD\  (via drill 0.61)
  Top 0.254: v134.62,71.75 134.62,65.41 130.18,60.96 130.18,52.7 129.54,52.07 129.54,39.37 130.18,38.73 130.18,24.13 127.64,21.59 127.64,5.08 121.92,5.08 120.02,6.99 IC23.6 | v146.05,73.03 147.32,74.3 147.32,109.22 148.59,110.49 148.59,135.89 150.5,137.79 150.5,140.34 v153.03,142.88
  Bottom 0.254: v134.62,71.75 135.89,73.03 v146.05,73.03 | v153.03,142.88 153.67,142.24 161.29,142.24 161.93,142.88 210.82,142.88 225.43,128.27 225.43,107.31 219.07,107.31 IC12.12
PBIT  (via drill 0.61)
  Top 0.254: v61.59,90.17 60.96,89.53 60.96,43.81 62.23,42.55 62.23,24.13 67.31,24.13 73.03,18.41 IC35.11 | v58.42,93.34 57.15,94.61 57.15,109.22 58.42,110.49 IC14.6
  Bottom 0.254: v61.59,90.17 v58.42,93.34
PCA
  Bottom 0.254: IC40.5 151.13,12.7 152.4,13.97 179.07,13.97 180.34,12.7 209.55,12.7 IC37.8 212.09,12.7 213.36,11.43 224.16,11.43 224.16,95.89 219.71,100.33 217.17,100.33 211.46,106.05 IC12.3
PER  (via drill 0.61)  (1 unrouted)
  Top 0.254: v204.47,64.77 204.47,129.54 203.2,130.81 203.2,138.43 191.13,150.5 143.51,150.5 143.51,134.62 142.24,133.35 IC9.9 | v34.29,31.75 34.29,23.5 36.83,20.95 36.83,9.53 38.1,8.26 SV1.21 | v166.37,37.47 168.91,34.92 v168.91,33.66 | IC54.11 269.24,171.45 267.97,170.18 267.97,153.03 269.24,151.76 SV3.21
  Bottom 0.254: v204.47,64.77 210.19,59.05 IC30.2 211.46,57.78 216.53,57.78 217.17,57.15 220.98,57.15 220.98,38.1 217.17,34.29 169.54,34.29 v168.91,33.66 | v34.29,31.75 36.83,34.29 127.64,34.29 129.54,36.2 149.86,36.2 151.13,37.47 v166.37,37.47
PER\  (via drill 0.61)
  Top 0.254: v146.05,102.87 146.05,129.54 144.78,130.81 IC9.8 | v157.48,102.87 160.02,105.41 v160.02,107.31
  Bottom 0.254: v157.48,102.87 v146.05,102.87 | v160.02,107.31 206.38,107.31 209.55,104.14 IC12.4
PIE  (via drill 0.61)  (1 unrouted)
  Top 0.254: v186.06,4.45 190.5,8.89 INTENB.2 | v153.03,5.08 151.76,6.35 | 151.76,6.35 151.76,13.34 150.5,14.61 IC40.4 | v221.62,8.26 221.62,50.16 219.07,52.7 IC30.17 | 151.76,6.35 151.76,1.91 101.6,1.91 98.42,5.08 98.42,9.53 93.34,9.53 92.71,8.89 92.71,1.91 24.13,1.91 18.41,7.62 SV1.5 | v62.23,178.44 62.23,177.8 58.42,173.99 IC48.13 | v158.75,175.9 166.37,168.28 166.37,164.47 174.62,156.21 234.31,156.21 v234.31,158.75 | v241.94,158.75 v241.94,154.94
  Bottom 0.254: v153.03,5.08 185.42,5.08 v186.06,4.45 217.81,4.45 v221.62,8.26 | v62.23,178.44 62.87,177.8 149.86,177.8 150.5,178.44 151.76,178.44 152.4,177.8 156.84,177.8 v158.75,175.9 | v234.31,158.75 v241.94,158.75 | v241.94,154.94 241.94,152.4 247.01,152.4 248.28,151.13 SV3.5
PROTECT  (via drill 0.61)
  Top 0.254: v142.24,140.97 142.24,138.43 IC5.6 | v162.56,140.97 162.56,138.43 IC6.3
  Bottom 0.254: v142.24,140.97 v162.56,140.97
SETNXD\
  Top 0.254: IC23.4 113.67,6.99 112.39,5.71 99.06,5.71 99.06,17.14 91.44,24.77 91.44,43.18 92.08,43.81 92.08,94.61 92.71,95.25 92.71,99.69 91.44,100.97 91.44,102.87 IC21.9
SETPER\
  Bottom 0.254: IC13.5 27.3,112.39 25.4,114.3 22.86,114.3 19.05,118.11 19.05,122.56 12.06,122.56 11.43,123.19 11.43,129.54 137.16,129.54 139.06,131.44 IC9.10
SETWLS\  (via drill 0.61)
  Top 0.254: v139.7,128.27 137.16,125.73 IC9.4 | v171.45,130.18 171.45,134.62 172.72,135.89 IC6.7
  Bottom 0.254: v139.7,128.27 140.97,129.54 160.02,129.54 160.66,130.18 v171.45,130.18
SKIP\  (via drill 0.61)
  Top 0.254: IC19.6 198.12,90.17 195.58,92.71 195.58,95.25 IC19.10 195.58,97.79 v195.58,104.14 | v132.08,104.78 132.08,110.49 IC17.2
  Bottom 0.254: R1.1 183.51,86.36 184.15,87 186.06,87 187.32,88.27 IC19.2 188.59,88.27 189.87,87 196.22,87 197.49,88.27 IC19.6 | v132.08,104.78 144.15,104.78 144.78,105.41 169.54,105.41 170.81,104.14 v195.58,104.14
START\  (via drill 0.61)
  Top 0.254: 144.15,45.09 144.15,14.61 142.88,13.34 DMA0-3.11 | 144.15,45.09 142.88,46.35 DMA4-7.11 | 144.15,45.09 144.15,79.38 142.88,80.64 DMA8-11.11 | v162.56,100.33 162.56,110.49 IC18.3 | v146.05,99.69 v146.05,81.28
  Bottom 0.254: v162.56,100.33 149.86,100.33 148.59,99.06 146.69,99.06 v146.05,99.69 | v146.05,81.28 143.51,81.28 DMA8-11.11
VCC  (via drill 0.61)  (3 unrouted)
  Top 0.508: J7.2 193.04,41.27 191.13,43.18 191.13,45.72 193.04,47.62 J5.2 193.04,48.9 193.04,50.16 J4.2 193.04,51.44 193.04,52.7 J3.2 | 187.96,29.21 v187.96,40.64 | 187.96,29.21 187.96,19.05 INTENB.16 | IC31.20 172.09,65.41 171.45,66.04 171.45,66.67 C31.1 | IC38.20 172.09,31.11 171.45,31.75 171.45,32.38 C38.1 | IC40.14 156.84,23.5 156.21,24.13 156.21,24.77 C40.1 156.21,26.04 155.57,26.67 v155.57,27.94 | 139.7,60.33 v139.06,59.69 | 139.7,60.33 139.7,61.59 140.34,62.23 C39.1 | 139.7,60.33 139.7,40.64 140.34,40.01 140.34,29.21 140.97,28.57 C46.1 | v186.69,29.21 187.96,29.21 | IC37.20 217.81,31.11 217.17,31.75 217.17,32.38 C37.1 | IC30.20 217.81,61.59 217.17,62.23 217.17,62.87 C30.1 216.53,63.5 216.53,87 217.81,88.27 FIELD.16 217.81,89.53 217.17,90.17 217.17,90.81 C44.1 217.17,92.08 216.53,92.71 216.53,109.86 217.81,111.12 IC12.14 217.81,112.39 217.17,113.03 217.17,113.67 C12.1 | IC17.16 129.54,120.65 128.27,121.92 128.27,128.91 127,130.18 C9.1 127,131.44 125.73,132.72 125.73,141.6 127,142.88 C5.1 | 153.67,128.91 154.94,130.18 C10.1 | 153.67,128.91 152.4,127.64 152.4,121.28 154.94,118.75 C18.1 154.94,117.47 155.57,116.84 155.57,114.3 156.21,113.67 156.21,97.16 C27.1 156.21,95.89 156.21,95.25 156.84,94.61 DAR8-11.16 156.84,93.34 154.94,91.44 154.94,64.14 156.21,62.87 C42.1 | 153.67,128.91 153.67,141.6 154.94,142.88 C6.1 | DMA8-11.16 141.6,94.61 140.97,95.25 140.97,95.89 C8.1 | IC24.20 172.09,99.69 171.45,100.33 171.45,100.97 C24.1 | C19.1 185.42,98.42 185.42,97.79 IC19.14 | IC11.4 193.04,113.03 195.58,115.57 195.58,118.11 IC11.10 | 181.61,120.02 181.61,128.91 180.34,130.18 C7.1
  Top 0.508: 181.61,120.02 182.88,118.75 C11.1 | RA.1 210.19,119.38 208.91,119.38 RL.1 208.28,120.02 208.28,121.92 210.19,123.83 IC8.4 210.19,125.09 206.38,128.91 206.38,138.43 C45.+ | C43X.1 220.98,130.18 219.71,131.44 219.71,132.08 IC8.8 | 181.61,120.02 181.61,98.42 182.88,97.16 R1.2 | 49.53,109.22 45.72,105.41 IC33.16 | 50.16,109.86 49.53,109.22 | 50.16,109.86 50.8,110.49 IC14.3 | 49.53,109.22 49.53,121.28 47.62,121.28 46.35,120.02 IC14.14 | 36.83,140.97 36.83,125.73 43.18,119.38 43.18,118.75 C14.1 | 36.83,140.97 36.83,141.6 38.1,142.88 C2.1 | IC20.20 12.7,105.41 13.34,106.05 13.34,115.57 15.24,117.47 C13.1 | 36.83,140.97 v36.2,140.97 | 80.01,120.65 80.01,114.3 78.74,113.03 IC15.3 | 80.01,120.65 79.38,121.28 73.66,121.28 73.66,120.65 IC15.14 | v73.66,107.31 73.66,105.41 IC21.16 | IC16.16 99.06,118.11 100.33,116.84 100.33,106.68 101.6,105.41 IC22.14 | 92.71,125.09 92.71,141.6 93.98,142.88 C4.1 | 92.71,125.09 96.52,121.28 96.52,118.75 C16.1 | 80.01,120.65 81.92,122.56 91.44,122.56 91.44,123.83 92.71,125.09 | IC34.20 29.84,41.27 29.21,41.91 29.21,42.55 C34.1 | v43.18,15.88 43.18,10.79 SV1.26 43.18,9.53 43.18,8.26 SV1.25 | v33.66,40.64 33.02,40.01 33.02,20.95 35.56,18.41 R2.2 | IC28.20 73.03,74.3 73.03,74.93 72.39,75.56 C28.1 72.39,76.83 73.66,78.11 v73.66,80.01 | C26.1 29.21,75.56 29.84,74.93 29.84,74.3 IC26.20 | v40.64,73.66 40.64,71.75 RS08.2 | 92.71,62.87 92.71,51.44 93.98,50.16 C32.1 93.98,48.9 92.71,47.62 92.71,42.55 96.52,38.73 96.52,31.75 IC36.16 | 92.71,62.87 93.98,64.14 C29.1 | 92.71,62.87 92.71,78.11 93.98,79.38 C25.1 | IC35.20 73.03,41.27 72.39,41.91 72.39,42.55 C35.1
  Top 0.508: IC36.6 109.22,21.59 106.68,19.05 106.68,16.51 IC23.14 | v79.38,40.64 78.74,40.01 78.74,16.51 IC41.16 | v74.3,9.53 76.2,11.43 76.2,13.34 C41.1 | C22.1 99.06,102.23 96.52,99.69 96.52,82.55 IC25.16 | 50.16,109.86 51.44,108.58 v51.44,107.95 | v99.69,147.96 97.16,145.41 IC4.16 | D1.A 236.22,57.15 237.49,58.42 238.12,58.42 RF08A.2 | D6.A 236.85,122.56 238.12,123.83 238.12,124.46 RF08B.2 | 260.35,184.78 260.35,185.42 261.62,186.69 IC53.14 | 260.35,184.78 260.35,175.26 261.62,173.99 IC54.14 261.62,171.45 260.35,170.18 v260.35,160.02 | R28.2 244.47,193.04 245.75,193.04 R16.2 247.01,193.04 249.56,193.04 256.54,186.06 256.54,184.78 260.35,184.78 | R26.2 214,193.04 215.26,193.04 R14.2 216.53,193.04 227.97,193.04 R27.2 229.24,193.04 230.5,193.04 R15.2 | SV3.25 274.32,151.76 274.32,153.03 SV3.26 | R50.2 215.26,160.02 214,160.02 R38.2 212.72,160.02 211.46,158.75 200.66,158.75 v200.66,160.66 | R39.2 229.24,160.02 230.5,160.02 R51.2 | IC48.14 55.88,173.99 54.61,175.26 54.61,185.42 55.88,186.69 IC47.14 | R7.2 40.01,193.04 38.73,193.04 R19.2 37.47,193.04 26.04,193.04 R6.2 24.77,193.04 23.5,193.04 R18.2 22.23,193.04 10.79,193.04 R5.2 9.53,193.04 8.89,193.04 | 8.89,193.04 8.26,193.04 R17.2 | 8.89,193.04 8.89,161.93 7.62,160.66 R29.2 8.26,160.02 9.53,160.02 R41.2 10.79,160.02 22.23,160.02 R30.2 23.5,160.02 24.77,160.02 R42.2 26.04,160.02 37.47,160.02 R31.2 38.73,160.02 40.01,160.02 R43.2 41.27,160.02 75.56,160.02 R32.2 | 123.19,181.61 123.19,186.69 124.46,187.96 IC49.14 | 123.19,181.61 123.19,175.26 124.46,173.99 IC50.14 | 107.95,160.02 108.58,160.02 R46.2 | 107.95,160.02 107.31,160.02 R34.2 106.05,160.02 94.61,160.02 R45.2 93.34,160.02 92.08,160.02 R33.2 90.81,160.02 90.81,158.12 83.82,158.12 81.92,160.02 79.38,160.02 R44.2
  Top 0.508: 123.19,181.61 116.2,181.61 116.2,179.07 107.95,170.81 107.95,160.02 | R37.2 175.9,160.02 177.16,160.02 R49.2 177.8,160.66 181.61,164.47 181.61,191.13 | R35.2 145.41,160.02 146.69,160.02 R47.2 147.96,160.02 150.5,160.02 152.4,158.12 159.38,158.12 159.38,160.02 R36.2 160.66,160.02 161.93,160.02 R48.2 | R10.2 108.58,193.04 107.31,193.04 R22.2 106.05,193.04 94.61,193.04 R9.2 93.34,193.04 92.08,193.04 R21.2 90.81,193.04 79.38,193.04 R8.2 78.11,193.04 76.83,193.04 R20.2 | IC52.14 193.04,173.99 191.77,175.26 191.77,184.78 193.04,186.06 193.04,186.69 IC51.14 192.41,188.59 184.15,188.59 181.61,191.13 | R12.2 161.93,193.04 160.66,193.04 R24.2 159.38,193.04 147.96,193.04 R11.2 | 181.61,191.13 179.71,193.04 178.44,193.04 R13.2
  Bottom 0.508: C43.1 186.06,16.51 186.69,17.14 187.32,17.14 INTENB.16 | v187.96,40.64 192.41,40.64 J7.2 | DMA0-3.16 142.24,26.04 140.97,27.3 C46.1 141.6,27.94 v155.57,27.94 156.84,29.21 170.18,29.21 | 154.31,63.5 142.88,63.5 141.6,62.23 C39.1 | 154.31,63.5 155.57,62.23 C42.1 156.21,61.59 156.84,61.59 156.84,60.33 DAR4-7.16 | v139.06,59.69 140.97,59.69 DMA4-7.16 | 170.18,29.21 171.45,30.48 IC38.20 | 154.31,63.5 166.37,63.5 167,64.14 170.81,64.14 171.45,64.77 IC31.20 | 170.18,29.21 v186.69,29.21 | C37.1 217.81,33.02 221.62,36.83 221.62,60.33 219.07,60.33 IC30.20 | C17.1 127.64,118.11 128.27,118.75 128.91,118.75 IC17.16 | C9.1 127.64,130.81 128.27,131.44 128.91,131.44 IC9.14 | IC6.16 156.84,144.15 156.21,144.15 155.57,143.51 C6.1 154.94,144.15 152.4,144.15 151.13,142.88 131.44,142.88 130.18,144.15 IC5.14 128.91,144.15 128.27,144.15 127.64,143.51 C5.1 126.36,143.51 118.11,143.51 113.67,147.96 v99.69,147.96 | C18.1 155.57,118.11 156.21,118.75 156.84,118.75 IC18.14 | C10.1 155.57,130.81 156.21,131.44 156.84,131.44 IC10.14 | C8.1 141.6,96.52 142.24,95.89 149.86,95.89 150.5,95.25 153.03,95.25 154.31,96.52 155.57,96.52 C27.1 156.84,96.52 158.12,97.79 170.18,97.79 171.45,99.06 IC24.20 173.99,99.06 176.53,96.52 182.25,96.52 R1.2 183.51,96.52 184.78,96.52 IC19.14 | C7.1 180.97,130.81 181.61,131.44 182.25,131.44 IC7.16 | C11.1 183.51,118.11 184.15,118.75 184.78,118.75 IC11.14 186.06,120.02 187.32,121.28 193.68,121.28 194.94,120.02 IC11.10 196.22,118.75 197.49,117.47 213.36,117.47 | 213.36,117.47 211.46,119.38 RA.1 | 213.36,117.47 216.53,114.3 C12.1 | IC8.8 217.17,132.08 210.19,139.06 207.01,139.06 C45.+
  Bottom 0.508: C2.1 38.73,143.51 39.37,144.15 40.01,144.15 IC2.16 | C14.1 43.81,118.11 44.45,118.75 45.09,118.75 IC14.14 | C33.1 43.81,102.87 44.45,103.5 45.09,103.5 IC33.16 | IC3.16 67.94,144.15 67.31,144.15 66.67,143.51 C3.1 65.41,143.51 63.5,141.6 36.2,141.6 | IC1.16 12.06,144.15 11.43,144.15 10.79,143.51 C1.1 10.16,142.88 8.89,141.6 | C20.1 10.79,102.87 11.43,103.5 12.06,103.5 IC20.20 | IC13.3 22.86,113.03 17.78,118.11 IC13.14 17.14,118.75 16.51,118.75 15.88,118.11 C13.1 15.24,118.75 6.99,118.75 6.99,139.7 8.89,141.6 | 36.2,141.6 8.89,141.6 | v36.2,140.97 36.2,141.6 | C15.1 71.75,118.11 72.39,118.75 73.03,118.75 IC15.14 | C4.1 94.61,143.51 95.25,144.15 95.89,144.15 IC4.16 | C16.1 97.16,118.11 97.79,118.75 98.42,118.75 IC16.16 | C21.1 71.75,102.87 72.39,103.5 73.03,103.5 IC21.16 | IC22.14 100.97,103.5 100.33,103.5 99.69,102.87 C22.1 98.42,102.87 95.25,106.05 86.36,106.05 85.09,107.31 v73.66,107.31 73.03,106.68 52.7,106.68 v51.44,107.95 | v43.18,15.88 38.1,15.88 36.2,17.78 R2.2 | v33.66,40.64 31.75,40.64 IC34.20 | v40.64,73.66 31.75,73.66 IC26.20 | C28.1 71.75,76.2 70.48,74.93 64.77,74.93 63.5,76.2 29.84,76.2 C26.1 | IC25.16 95.89,80.64 95.25,80.64 94.61,80.01 C25.1 93.34,80.01 v73.66,80.01 | C32.1 94.61,49.53 95.25,50.16 95.89,50.16 IC32.16 | C29.1 94.61,64.77 95.25,65.41 95.89,65.41 IC29.16 | C36.1 94.61,29.21 95.25,29.84 95.89,29.84 IC36.16 97.16,29.84 102.87,24.13 102.87,20.95 107.31,20.95 108.58,22.23 IC36.6 | C41.1 76.83,13.97 77.47,14.61 78.11,14.61 IC41.16 79.38,15.88 80.64,17.14 100.33,17.14 103.5,13.97 C23.1 104.78,13.97 105.41,14.61 106.05,14.61 IC23.14
  Bottom 0.508: v79.38,40.64 74.93,40.64 IC35.20 | v74.3,9.53 73.03,8.26 44.45,8.26 43.81,7.62 SV1.25 | R28.2 243.21,193.04 231.78,193.04 R15.2 | R50.2 216.53,160.02 227.97,160.02 R39.2 | R51.2 231.78,160.02 243.21,160.02 R40.2 244.47,160.02 245.75,160.02 R52.2 247.01,160.02 v260.35,160.02 267.33,160.02 273.69,153.67 SV3.26 | IC47.14 55.24,187.32 54.61,186.69 42.55,186.69 40.64,188.59 40.64,192.41 R7.2 | R32.2 76.83,160.02 78.11,160.02 R44.2 | R37.2 174.62,160.02 163.19,160.02 R48.2 | R13.2 177.16,193.04 175.9,193.04 R25.2 174.62,193.04 168.91,193.04 168.28,193.68 162.56,193.68 R12.2 | R11.2 146.69,193.04 145.41,193.04 R23.2 144.15,193.04 109.86,193.04 R10.2 | R46.2 109.86,160.02 144.15,160.02 R35.2 | v200.66,160.66 200.03,161.29 192.41,161.29 191.13,160.02 178.44,160.02 R49.2
WE\  (via drill 0.61)  (2 unrouted)
  Top 0.254: v112.39,100.33 112.39,98.42 111.76,97.79 IC22.5 111.76,95.25 111.76,90.17 v110.49,88.9 | v148.59,100.33 151.76,103.5 v151.76,139.7 | v42.55,68.58 42.55,66.04 40.64,64.14 RS08.8 | v53.98,70.48 54.61,71.12 v54.61,87.63 | IC43.29 246.38,22.86 246.38,27.3 245.11,28.57 245.11,31.75 246.38,33.02 246.38,44.45 IC42.29 246.38,46.99 246.38,52.7 245.11,53.98 245.11,57.78 245.75,58.42 RF08A.8 | IC45.29 246.38,87.63 245.11,88.9 245.11,97.79 245.75,98.42 245.75,111.12 IC39.29 246.38,113.03 245.11,114.3 245.11,122.56 246.38,123.83 RF08B.8
  Bottom 0.254: v112.39,100.33 113.03,99.69 123.83,99.69 125.09,100.97 147.96,100.97 v148.59,100.33 | v151.76,139.7 152.4,140.34 161.93,140.34 163.19,139.06 165.74,139.06 167,137.79 IC6.5 | v42.55,68.58 44.45,70.48 v53.98,70.48 | v54.61,87.63 97.79,87.63 99.06,88.9 v110.49,88.9
WLS  (via drill 0.61)  (1 unrouted)
  Top 0.254: v140.97,148.59 140.97,127 139.7,125.73 IC9.5 | v204.47,144.15 213.36,135.25 213.36,25.4 211.46,23.5 IC37.4 | v216.53,165.1 210.82,159.38 208.28,159.38 204.47,163.19 204.47,167.64 200.66,171.45 IC52.11 | v258.44,164.47 259.08,163.83 259.08,155.57 260.35,154.31 260.35,153.03 261.62,151.76 SV3.15
  Bottom 0.254: v204.47,144.15 198.75,149.86 142.24,149.86 v140.97,148.59 139.06,150.5 15.88,150.5 10.79,145.41 2.54,145.41 2.54,15.88 12.06,6.35 28.57,6.35 29.84,7.62 SV1.15 | v216.53,165.1 217.81,163.83 257.81,163.83 v258.44,164.47
WLS\  (via drill 0.61)
  Top 0.254: v142.24,128.27 142.24,125.73 IC9.6
  Bottom 0.254: v142.24,128.27 142.88,128.91 160.66,128.91 161.29,129.54 170.81,129.54 171.45,128.91 196.22,128.91 199.39,125.73 199.39,121.28 209.55,121.28 210.19,120.65 212.72,120.65 220.34,113.03 220.34,109.86 219.07,109.86 IC12.13
WRITING  (via drill 0.61)  (3 unrouted)
  Top 0.254: 156.84,135.25 156.21,135.89 156.21,142.24 162.56,142.24 166.37,138.43 166.37,135.89 168.91,133.35 168.91,127 167.64,125.73 IC10.5 | 156.84,135.25 159.38,135.25 159.38,136.53 IC6.2 | v49.53,50.16 49.53,48.26 48.9,47.62 v48.9,11.43 48.9,5.08 24.77,5.08 22.86,6.99 SV1.9 | v82.55,12.06 82.55,12.7 83.82,13.97 IC41.14 | 156.84,135.25 156.21,134.62 156.21,129.54 153.67,127 v153.67,124.46 | v110.49,128.27 107.95,125.73 107.95,123.19 106.05,121.28 97.79,121.28 97.79,106.05 100.33,103.5 100.33,90.17 97.79,87.63 v97.79,76.83 | v87.63,76.2 87.63,18.41 86.36,17.14 86.36,16.51 IC41.13 | IC43.24 259.08,22.86 259.08,27.3 257.81,28.57 257.81,31.75 259.08,33.02 259.08,44.45 IC42.24 259.08,46.99 259.08,52.7 257.81,53.98 257.81,57.78 258.44,58.42 RF08A.18 | IC45.24 259.08,87.63 257.81,88.9 257.81,98.42 258.44,99.06 258.44,111.12 IC39.24 259.08,113.03 257.81,114.3 257.81,122.56 259.08,123.83 RF08B.18 | v135.89,161.93 135.89,167.64 132.08,171.45 IC50.11 | v210.19,162.56 210.82,163.19 v210.82,166.37 | v252.73,166.37 252.73,153.03 254,151.76 SV3.9
  Bottom 0.254: IC41.14 84.45,14.61 85.72,14.61 IC41.13 | v49.53,50.16 48.9,50.8 41.27,50.8 RS08.18 | v82.55,12.06 81.92,11.43 v48.9,11.43 | v153.67,124.46 152.4,123.19 146.05,123.19 145.41,122.56 136.53,122.56 135.89,123.19 135.89,126.36 133.99,126.36 132.08,128.27 v110.49,128.27 | v97.79,76.83 97.16,76.2 v87.63,76.2 | v135.89,161.93 136.53,162.56 v210.19,162.56 | v210.82,166.37 v252.73,166.37

## Text on the board
Bottom: RF08 Debug | VRS | VRS | RS08 | VRS | RS08 | RF08 | VRS
tPlace: RF08 | VRS
tValues: RF08 Debug | VRS | RS08 | VRS | RS08 | VRS